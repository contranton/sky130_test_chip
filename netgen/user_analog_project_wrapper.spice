* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt switch-small a_130480_557030# a_130580_557030# SIgnal
X0 a_130220_557340# SIgnal GND GND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=5.075e+11p ps=4.3e+06u w=450000u l=150000u
X1 a_130580_557030# a_130220_557340# a_130480_557030# VDD sky130_fd_pr__pfet_01v8 ad=7e+11p pd=5.4e+06u as=3.5e+11p ps=2.7e+06u w=1e+06u l=150000u
X2 a_130220_557340# SIgnal VDD VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=1.575e+11p ps=1.6e+06u w=450000u l=150000u
X3 a_130580_557030# SIgnal a_130480_557030# GND sky130_fd_pr__nfet_01v8 ad=7e+11p pd=5.4e+06u as=3.5e+11p ps=2.7e+06u w=1e+06u l=150000u
X4 GND SIgnal a_130580_557030# VDD sky130_fd_pr__pfet_01v8 ad=1.45e+12p pd=8.9e+06u as=0p ps=0u w=1e+06u l=150000u
X5 GND a_130220_557340# a_130580_557030# GND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.97e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.97e+06u
.ends

.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VPWR Q VNB VPB
X0 Q a_1059_315# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=7.492e+11p ps=8.11e+06u w=650000u l=150000u
X1 a_891_413# a_193_47# a_634_159# VNB sky130_fd_pr__nfet_01v8 ad=1.368e+11p pd=1.48e+06u as=1.978e+11p ps=1.99e+06u w=360000u l=150000u
X2 a_561_413# a_27_47# a_466_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.533e+11p pd=1.57e+06u as=1.365e+11p ps=1.49e+06u w=420000u l=150000u
X3 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.02105e+12p pd=9.61e+06u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X4 Q a_1059_315# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X5 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.155e+11p pd=1.39e+06u as=0p ps=0u w=420000u l=150000u
X6 VGND a_634_159# a_592_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.392e+11p ps=1.53e+06u w=420000u l=150000u
X7 VPWR a_891_413# a_1059_315# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X8 a_466_413# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 VPWR a_634_159# a_561_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X10 a_634_159# a_466_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X11 a_634_159# a_466_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.19e+11p pd=2.15e+06u as=0p ps=0u w=750000u l=150000u
X12 a_975_413# a_193_47# a_891_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.764e+11p pd=1.68e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X13 VGND a_1059_315# a_1017_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.32e+11p ps=1.49e+06u w=420000u l=150000u
X14 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X15 a_891_413# a_27_47# a_634_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 a_592_47# a_193_47# a_466_413# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.242e+11p ps=1.41e+06u w=360000u l=150000u
X17 a_1017_47# a_27_47# a_891_413# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X18 VPWR a_1059_315# a_975_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 a_466_413# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.626e+11p ps=1.66e+06u w=360000u l=150000u
X20 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X21 VGND a_891_413# a_1059_315# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X22 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__decap_12 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=4.73e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=4.73e+06u
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=1.05e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=1.05e+06u
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=590000u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=590000u
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VPWR VNB VPB
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=4.524e+11p pd=4.52e+06u as=0p ps=0u w=870000u l=2.89e+06u
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=2.86e+11p pd=3.24e+06u as=0p ps=0u w=550000u l=2.89e+06u
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VPWR X VNB VPB
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VPWR X VNB VPB
X0 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.24e+12p pd=2.048e+07u as=3.045e+12p ps=2.809e+07u w=1e+06u l=150000u
X1 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.6e+11p pd=5.12e+06u as=0p ps=0u w=1e+06u l=150000u
X5 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=2.352e+11p pd=2.8e+06u as=1.2789e+12p ps=1.533e+07u w=420000u l=150000u
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=9.408e+11p ps=1.12e+07u w=420000u l=150000u
X7 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X9 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X13 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X15 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X16 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X17 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X18 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X20 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X23 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X28 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X29 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X30 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X31 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X32 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X33 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X34 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X38 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X39 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VPWR Q VNB VPB
X0 Q a_1059_315# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.755e+11p pd=1.84e+06u as=9.182e+11p ps=9.93e+06u w=650000u l=150000u
X1 a_891_413# a_193_47# a_634_159# VNB sky130_fd_pr__nfet_01v8 ad=1.368e+11p pd=1.48e+06u as=1.978e+11p ps=1.99e+06u w=360000u l=150000u
X2 VPWR a_1059_315# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=1.28105e+12p pd=1.213e+07u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X3 a_561_413# a_27_47# a_466_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.533e+11p pd=1.57e+06u as=1.365e+11p ps=1.49e+06u w=420000u l=150000u
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=1.664e+11p ps=1.8e+06u w=640000u l=150000u
X5 Q a_1059_315# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.155e+11p pd=1.39e+06u as=0p ps=0u w=420000u l=150000u
X7 VGND a_634_159# a_592_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.392e+11p ps=1.53e+06u w=420000u l=150000u
X8 VGND a_1059_315# Q VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X9 VPWR a_891_413# a_1059_315# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X10 a_466_413# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X11 VPWR a_634_159# a_561_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X12 a_634_159# a_466_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=640000u l=150000u
X13 a_634_159# a_466_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.19e+11p pd=2.15e+06u as=0p ps=0u w=750000u l=150000u
X14 a_975_413# a_193_47# a_891_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=1.764e+11p pd=1.68e+06u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X15 VGND a_1059_315# a_1017_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.32e+11p ps=1.49e+06u w=420000u l=150000u
X16 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.092e+11p pd=1.36e+06u as=0p ps=0u w=420000u l=150000u
X17 a_891_413# a_27_47# a_634_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X18 a_592_47# a_193_47# a_466_413# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.242e+11p ps=1.41e+06u w=360000u l=150000u
X19 a_1017_47# a_27_47# a_891_413# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=360000u l=150000u
X20 VPWR a_1059_315# a_975_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X21 a_466_413# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.626e+11p ps=1.66e+06u w=360000u l=150000u
X22 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=1.664e+11p pd=1.8e+06u as=0p ps=0u w=640000u l=150000u
X23 VGND a_891_413# a_1059_315# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X24 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X25 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VPB VPWR VNB
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=5.36e+06u area=4.347e+11p
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VPWR X VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=5.85e+11p pd=5.17e+06u as=2.65e+11p ps=2.53e+06u w=1e+06u l=150000u
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.7e+11p ps=2.54e+06u w=1e+06u l=150000u
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=2.457e+11p pd=2.85e+06u as=1.113e+11p ps=1.37e+06u w=420000u l=150000u
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.134e+11p pd=1.38e+06u as=0p ps=0u w=420000u l=150000u
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
.ends

.subckt shift_reg clk din out_window[0] out_window[1] out_window[2] out_window[3]
+ VPWR VGND
XFILLER_67_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0367_ _1088_/CLK _0367_/D VGND VPWR _0368_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_266 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0298_ _0316_/CLK _0298_/D VGND VPWR _0299_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1270_ _1302_/CLK _1270_/D VGND VPWR _1271_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0221_ _0316_/CLK _0221_/D VGND VPWR _0222_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0152_ _1162_/CLK _0152_/D VGND VPWR _0153_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_364 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_386 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0083_ _1229_/CLK _0083_/D VGND VPWR _0084_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_464 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0985_ _1017_/CLK _0985_/D VGND VPWR _0986_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_8_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1606_ _1611_/CLK _1606_/D VGND VPWR _1607_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1537_ _1578_/CLK _1537_/D VGND VPWR _1538_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1468_ _1687_/CLK _1468_/D VGND VPWR _1469_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1399_ _1754_/CLK _1399_/D VGND VPWR _1400_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0419_ _1077_/CLK _0419_/D VGND VPWR _0420_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_342 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_604 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_537 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_453 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0770_ _1827_/CLK _0770_/D VGND VPWR _0781_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1322_ _1788_/CLK _1322_/D VGND VPWR _1323_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_158 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1253_ _1272_/CLK _1253_/D VGND VPWR _1254_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0204_ _1178_/CLK _0204_/D VGND VPWR _0205_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1184_ _1185_/CLK _1184_/D VGND VPWR _1185_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0135_ _1162_/CLK _0135_/D VGND VPWR _0136_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0066_ _1635_/CLK _0066_/D VGND VPWR _0077_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_12_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_12_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_0968_ _1826_/CLK _0968_/D VGND VPWR _0979_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0899_ _0908_/CLK _0899_/D VGND VPWR _0900_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_331 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1940_ _1956_/CLK _1940_/D VGND VPWR _1941_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1871_ _1995_/CLK _1871_/D VGND VPWR _1872_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0822_ _0831_/CLK _0822_/D VGND VPWR _0823_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0753_ _0761_/CLK _0753_/D VGND VPWR _0754_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0684_ _0898_/CLK _0684_/D VGND VPWR _0685_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_50_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1305_ _1320_/CLK _1305_/D VGND VPWR _1306_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1236_ _1244_/CLK _1236_/D VGND VPWR _1237_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1167_ _1170_/CLK _1167_/D VGND VPWR _1168_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0118_ _1138_/CLK _0118_/D VGND VPWR _0119_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1098_ _1103_/CLK _1098_/D VGND VPWR _1099_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0049_ _1841_/CLK _0049_/D VGND VPWR _0050_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_408 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_492 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_320 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1021_ _1033_/CLK _1021_/D VGND VPWR _1022_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1923_ _1936_/CLK _1923_/D VGND VPWR _1924_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1854_ _1862_/CLK _1854_/D VGND VPWR _1856_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1785_ _1788_/CLK _1785_/D VGND VPWR _1786_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0805_ _0906_/CLK _0805_/D VGND VPWR _0806_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0736_ _1147_/CLK _0736_/D VGND VPWR _0738_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0667_ _0916_/CLK _0667_/D VGND VPWR _0668_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0598_ _0632_/CLK _0598_/D VGND VPWR _0599_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1219_ _1228_/CLK _1219_/D VGND VPWR _1220_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_28 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_356 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_495 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1570_ _1592_/CLK _1570_/D VGND VPWR _1571_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0521_ _0529_/CLK _0521_/D VGND VPWR _0522_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0452_ _0585_/CLK _0452_/D VGND VPWR _0453_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0383_ _1103_/CLK _0383_/D VGND VPWR _0384_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1004_ _1010_/CLK _1004_/D VGND VPWR _1005_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_359 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1906_ _1936_/CLK _1906_/D VGND VPWR _1907_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1837_ _1846_/CLK _1837_/D VGND VPWR _1838_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1768_ _1772_/CLK _1768_/D VGND VPWR _1769_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1699_ _1710_/CLK _1699_/D VGND VPWR _1700_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_626 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0719_ _0793_/CLK _0719_/D VGND VPWR _0720_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_114_clk clkbuf_4_1_0_clk/X VGND VPWR _1747_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_0_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_170 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_105_clk clkbuf_4_6_0_clk/X VGND VPWR _1862_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1622_ _1673_/CLK _1622_/D VGND VPWR _1623_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1553_ _1592_/CLK _1553_/D VGND VPWR _1554_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1484_ _1965_/CLK _1484_/D VGND VPWR _1485_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0504_ _0508_/CLK _0504_/D VGND VPWR _0505_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0435_ _0973_/CLK _0435_/D VGND VPWR _0436_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_532 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0366_ _1112_/CLK _0366_/D VGND VPWR _0367_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0297_ _0539_/CLK _0297_/D VGND VPWR _0308_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_35_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0220_ _1594_/CLK _0220_/D VGND VPWR _0231_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0151_ _1170_/CLK _0151_/D VGND VPWR _0152_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0082_ _1229_/CLK _0082_/D VGND VPWR _0083_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_44_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0984_ _1039_/CLK _0984_/D VGND VPWR _0985_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1605_ _1611_/CLK _1605_/D VGND VPWR _1606_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1536_ _1578_/CLK _1536_/D VGND VPWR _1537_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1467_ _1726_/CLK _1467_/D VGND VPWR _1468_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_59_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1398_ _1754_/CLK _1398_/D VGND VPWR _1399_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0418_ _0539_/CLK _0418_/D VGND VPWR _0429_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0349_ _1181_/CLK _0349_/D VGND VPWR _0350_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_354 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_358 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1321_ _1788_/CLK _1321_/D VGND VPWR _1322_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_78_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1252_ _1272_/CLK _1252_/D VGND VPWR _1253_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0203_ _1178_/CLK _0203_/D VGND VPWR _0204_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1183_ _1578_/CLK _1183_/D VGND VPWR _1183_/Q VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0134_ _1228_/CLK _0134_/D VGND VPWR _0135_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0065_ _1185_/CLK _0065_/D VGND VPWR _0067_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0967_ _1039_/CLK _0967_/D VGND VPWR _0969_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0898_ _0898_/CLK _0898_/D VGND VPWR _0899_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1519_ _1587_/CLK _1519_/D VGND VPWR _1520_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_94_clk clkbuf_4_5_0_clk/X VGND VPWR _1600_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_43_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_85_clk clkbuf_4_7_0_clk/X VGND VPWR _1936_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1870_ _1997_/CLK _1870_/D VGND VPWR _1871_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0821_ _0831_/CLK _0821_/D VGND VPWR _0822_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0752_ _0761_/CLK _0752_/D VGND VPWR _0753_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0683_ _0898_/CLK _0683_/D VGND VPWR _0684_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_43_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1304_ _1320_/CLK _1304_/D VGND VPWR _1305_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_76_clk clkbuf_4_6_0_clk/X VGND VPWR _1858_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1235_ _1302_/CLK _1235_/D VGND VPWR _1236_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1166_ _1841_/CLK _1166_/D VGND VPWR _1177_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0117_ _0743_/CLK _0117_/D VGND VPWR _0118_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1097_ _1104_/CLK _1097_/D VGND VPWR _1098_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0048_ _0169_/CLK _0048_/D VGND VPWR _0049_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_28 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_67_clk clkbuf_4_13_0_clk/X VGND VPWR _0280_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_18_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_58_clk clkbuf_4_15_0_clk/X VGND VPWR _0573_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_11_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_11_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_1020_ _1039_/CLK _1020_/D VGND VPWR _1021_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_74_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_302 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1922_ _1936_/CLK _1922_/D VGND VPWR _1923_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1853_ _1997_/CLK _1853_/D VGND VPWR _1854_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0804_ _0906_/CLK _0804_/D VGND VPWR _0805_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1784_ _1788_/CLK _1784_/D VGND VPWR _1785_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0735_ _0743_/CLK _0735_/D VGND VPWR _0736_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0666_ _0908_/CLK _0666_/D VGND VPWR _0667_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_307 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0597_ _0610_/CLK _0597_/D VGND VPWR _0598_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_49_clk clkbuf_4_14_0_clk/X VGND VPWR _0966_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1218_ _1228_/CLK _1218_/D VGND VPWR _1219_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1149_ _1162_/CLK _1149_/D VGND VPWR _1150_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_59 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_622 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_578 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0520_ _0529_/CLK _0520_/D VGND VPWR _0521_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0451_ _1985_/CLK _0451_/D VGND VPWR _0462_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0382_ _1104_/CLK _0382_/D VGND VPWR _0383_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1003_ _1010_/CLK _1003_/D VGND VPWR _1004_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_50_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1905_ _1907_/CLK _1905_/D VGND VPWR _1906_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1836_ _1846_/CLK _1836_/D VGND VPWR _1837_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1767_ _1833_/CLK _1767_/D VGND VPWR _1778_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0718_ _0793_/CLK _0718_/D VGND VPWR _0719_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1698_ _1710_/CLK _1698_/D VGND VPWR _1699_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0649_ _1649_/CLK _0649_/D VGND VPWR _0660_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_182 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1621_ _1673_/CLK _1621_/D VGND VPWR _1622_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1552_ _1918_/CLK _1552_/D VGND VPWR _1553_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1483_ _1987_/CLK _1483_/D VGND VPWR _1484_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0503_ _0529_/CLK _0503_/D VGND VPWR _0504_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0434_ _0973_/CLK _0434_/D VGND VPWR _0435_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0365_ _1088_/CLK _0365_/D VGND VPWR _0366_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0296_ _0316_/CLK _0296_/D VGND VPWR _0298_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_50_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_411 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1819_ _1826_/CLK _1819_/D VGND VPWR _1820_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_102 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0150_ _1170_/CLK _0150_/D VGND VPWR _0151_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0081_ _1228_/CLK _0081_/D VGND VPWR _0082_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0983_ _1039_/CLK _0983_/D VGND VPWR _0984_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_73_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1604_ _1604_/CLK _1604_/D VGND VPWR _1605_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1535_ _1578_/CLK _1535_/D VGND VPWR _1536_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1466_ _1687_/CLK _1466_/D VGND VPWR _1467_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1397_ _1754_/CLK _1397_/D VGND VPWR _1398_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0417_ _1077_/CLK _0417_/D VGND VPWR _0419_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0348_ _1181_/CLK _0348_/D VGND VPWR _0349_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_182 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0279_ _1980_/CLK _0279_/D VGND VPWR _0280_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_326 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1320_ _1320_/CLK _1320_/D VGND VPWR _1321_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1251_ _1272_/CLK _1251_/D VGND VPWR _1252_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1182_ _1182_/CLK _1182_/D VGND VPWR _1183_/D VGND VPWR sky130_fd_sc_hd__dfxtp_2
X_0202_ _1178_/CLK _0202_/D VGND VPWR _0203_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0133_ _1138_/CLK _0133_/D VGND VPWR _0134_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_91_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0064_ _1185_/CLK _0064_/D VGND VPWR _0065_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0966_ _0966_/CLK _0966_/D VGND VPWR _0967_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_481 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0897_ _0908_/CLK _0897_/D VGND VPWR _0898_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1518_ _1604_/CLK _1518_/D VGND VPWR _1519_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1449_ _1695_/CLK _1449_/D VGND VPWR _1450_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_59_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_119 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_336 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0820_ _0831_/CLK _0820_/D VGND VPWR _0821_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0751_ _0761_/CLK _0751_/D VGND VPWR _0752_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0682_ _1862_/CLK _0682_/D VGND VPWR _0693_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1303_ _1336_/CLK _1303_/D VGND VPWR _1304_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1234_ _1302_/CLK _1234_/D VGND VPWR _1235_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1165_ _1170_/CLK _1165_/D VGND VPWR _1167_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_18_580 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1096_ _1104_/CLK _1096_/D VGND VPWR _1097_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0116_ _0743_/CLK _0116_/D VGND VPWR _0117_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0047_ _1841_/CLK _0047_/D VGND VPWR _0048_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0949_ _0953_/CLK _0949_/D VGND VPWR _0950_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_255 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_380 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_300 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1921_ _1965_/CLK _1921_/D VGND VPWR _1932_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1852_ _1862_/CLK _1852_/D VGND VPWR _1853_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0803_ _1827_/CLK _0803_/D VGND VPWR _0814_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1783_ _1783_/CLK _1783_/D VGND VPWR _1784_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0734_ _1147_/CLK _0734_/D VGND VPWR _0735_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0665_ _0908_/CLK _0665_/D VGND VPWR _0666_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0596_ _0610_/CLK _0596_/D VGND VPWR _0597_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1217_ _1816_/CLK _1217_/D VGND VPWR _1218_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1148_ _1162_/CLK _1148_/D VGND VPWR _1149_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1079_ _1104_/CLK _1079_/D VGND VPWR _1080_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_78 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_336 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0450_ _0585_/CLK _0450_/D VGND VPWR _0452_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0381_ _0906_/CLK _0381_/D VGND VPWR _0382_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1002_ _1010_/CLK _1002_/D VGND VPWR _1003_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_47_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1904_ _1985_/CLK _1904_/D VGND VPWR _1905_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1835_ _1846_/CLK _1835_/D VGND VPWR _1836_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1766_ _1772_/CLK _1766_/D VGND VPWR _1768_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0717_ _0793_/CLK _0717_/D VGND VPWR _0718_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1697_ _1710_/CLK _1697_/D VGND VPWR _1698_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_606 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0648_ _0919_/CLK _0648_/D VGND VPWR _0650_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0579_ _0585_/CLK _0579_/D VGND VPWR _0580_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_534 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_420 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_10_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_10_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_5_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_183 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_194 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1620_ _1965_/CLK _1620_/D VGND VPWR _1621_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1551_ _1918_/CLK _1551_/D VGND VPWR _1552_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1482_ _1965_/CLK _1482_/D VGND VPWR _1483_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0502_ _0508_/CLK _0502_/D VGND VPWR _0503_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0433_ _0973_/CLK _0433_/D VGND VPWR _0434_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0364_ _1112_/CLK _0364_/D VGND VPWR _0365_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0295_ _0295_/CLK _0295_/D VGND VPWR _0296_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1818_ _1841_/CLK _1818_/D VGND VPWR _1819_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1749_ _1783_/CLK _1749_/D VGND VPWR _1750_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_397 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0080_ _1228_/CLK _0080_/D VGND VPWR _0081_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0982_ _1017_/CLK _0982_/D VGND VPWR _0983_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_66_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1603_ _1604_/CLK _1603_/D VGND VPWR _1604_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1534_ _1578_/CLK _1534_/D VGND VPWR _1535_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1465_ _1687_/CLK _1465_/D VGND VPWR _1466_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1396_ _1754_/CLK _1396_/D VGND VPWR _1397_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0416_ _1077_/CLK _0416_/D VGND VPWR _0417_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0347_ _1181_/CLK _0347_/D VGND VPWR _0348_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_49 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0278_ _1980_/CLK _0278_/D VGND VPWR _0279_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_68 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_338 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1250_ _1272_/CLK _1250_/D VGND VPWR _1251_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1181_ _1181_/CLK _1181_/D VGND VPWR _1182_/D VGND VPWR sky130_fd_sc_hd__dfxtp_2
X_0201_ _1178_/CLK _0201_/D VGND VPWR _0202_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0132_ _1635_/CLK _0132_/D VGND VPWR _0143_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0063_ _1162_/CLK _0063_/D VGND VPWR _0064_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0965_ _0973_/CLK _0965_/D VGND VPWR _0966_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0896_ _0898_/CLK _0896_/D VGND VPWR _0897_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1517_ _1587_/CLK _1517_/D VGND VPWR _1518_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1448_ _1695_/CLK _1448_/D VGND VPWR _1449_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1379_ _1764_/CLK _1379_/D VGND VPWR _1380_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_34 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_586 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_621 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0750_ _0750_/CLK _0750_/D VGND VPWR _0751_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0681_ _0898_/CLK _0681_/D VGND VPWR _0683_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1302_ _1302_/CLK _1302_/D VGND VPWR _1303_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1233_ _1233_/CLK _1233_/D VGND VPWR _1234_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1164_ _1170_/CLK _1164_/D VGND VPWR _1165_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1095_ _1104_/CLK _1095_/D VGND VPWR _1096_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0115_ _1138_/CLK _0115_/D VGND VPWR _0116_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0046_ _0169_/CLK _0046_/D VGND VPWR _0047_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_551 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1997_ _1997_/CLK _1997_/D VGND VPWR _1997_/Q VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0948_ _0953_/CLK _0948_/D VGND VPWR _0949_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0879_ _0894_/CLK _0879_/D VGND VPWR _0881_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_212 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_216 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_50 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1920_ _1936_/CLK _1920_/D VGND VPWR _1922_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1851_ _1862_/CLK _1851_/D VGND VPWR _1852_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0802_ _0906_/CLK _0802_/D VGND VPWR _0804_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1782_ _1783_/CLK _1782_/D VGND VPWR _1783_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0733_ _0793_/CLK _0733_/D VGND VPWR _0734_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0664_ _0916_/CLK _0664_/D VGND VPWR _0665_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0595_ _0595_/CLK _0595_/D VGND VPWR _0596_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_215 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1216_ _1228_/CLK _1216_/D VGND VPWR _1217_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1147_ _1147_/CLK _1147_/D VGND VPWR _1148_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1078_ _1826_/CLK _1078_/D VGND VPWR _1089_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0029_ _1846_/CLK _0029_/D VGND VPWR _0030_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_462 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_87 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_156 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_117_clk clkbuf_4_0_0_clk/X VGND VPWR _1788_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_24_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0380_ _1103_/CLK _0380_/D VGND VPWR _0381_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_579 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_440 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1001_ _1686_/CLK _1001_/D VGND VPWR _1012_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_35_602 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_108_clk clkbuf_4_3_0_clk/X VGND VPWR _1686_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_96_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1903_ _1907_/CLK _1903_/D VGND VPWR _1904_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1834_ _1862_/CLK _1834_/D VGND VPWR _1835_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1765_ _1772_/CLK _1765_/D VGND VPWR _1766_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0716_ _0793_/CLK _0716_/D VGND VPWR _0717_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1696_ _1710_/CLK _1696_/D VGND VPWR _1697_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0647_ _0919_/CLK _0647_/D VGND VPWR _0648_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0578_ _0585_/CLK _0578_/D VGND VPWR _0579_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_546 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_384 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_151 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_140 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_184 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_195 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1550_ _1918_/CLK _1550_/D VGND VPWR _1551_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0501_ _0508_/CLK _0501_/D VGND VPWR _0502_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1481_ _1833_/CLK _1481_/D VGND VPWR _1482_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0432_ _0966_/CLK _0432_/D VGND VPWR _0433_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0363_ _1907_/CLK _0363_/D VGND VPWR _0374_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_11_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0294_ _0295_/CLK _0294_/D VGND VPWR _0295_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1817_ _1841_/CLK _1817_/D VGND VPWR _1818_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_2_509 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1748_ _1783_/CLK _1748_/D VGND VPWR _1749_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1679_ _1687_/CLK _1679_/D VGND VPWR _1680_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_148 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_314 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_240 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0981_ _1039_/CLK _0981_/D VGND VPWR _0982_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_12_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1602_ _1611_/CLK _1602_/D VGND VPWR _1603_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_59_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1533_ _1578_/CLK _1533_/D VGND VPWR _1534_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1464_ _1687_/CLK _1464_/D VGND VPWR _1465_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0415_ _1077_/CLK _0415_/D VGND VPWR _0416_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1395_ _1754_/CLK _1395_/D VGND VPWR _1396_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_310 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_162 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0346_ _1181_/CLK _0346_/D VGND VPWR _0347_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0277_ _1010_/CLK _0277_/D VGND VPWR _0278_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_35_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_30_clk clkbuf_4_10_0_clk/X VGND VPWR _0874_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_88_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_97_clk clkbuf_4_4_0_clk/X VGND VPWR _1987_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_85_151 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_21_clk clkbuf_4_8_0_clk/X VGND VPWR _0743_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_78_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_88_clk clkbuf_4_5_0_clk/X VGND VPWR _1594_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_49_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1180_ _1180_/CLK _1180_/D VGND VPWR _1181_/D VGND VPWR sky130_fd_sc_hd__dfxtp_2
X_0200_ _1178_/CLK _0200_/D VGND VPWR _0201_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0131_ _1147_/CLK _0131_/D VGND VPWR _0133_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_508 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0062_ _1185_/CLK _0062_/D VGND VPWR _0063_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0964_ _0966_/CLK _0964_/D VGND VPWR _0965_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_12_clk clkbuf_4_3_0_clk/X VGND VPWR _1185_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0895_ _0908_/CLK _0895_/D VGND VPWR _0896_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1516_ _1604_/CLK _1516_/D VGND VPWR _1517_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1447_ _1695_/CLK _1447_/D VGND VPWR _1448_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_79_clk clkbuf_4_6_0_clk/X VGND VPWR _1649_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1378_ _1764_/CLK _1378_/D VGND VPWR _1379_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0329_ _1070_/CLK _0329_/D VGND VPWR _0331_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_298 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_442 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0680_ _0898_/CLK _0680_/D VGND VPWR _0681_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1301_ _1320_/CLK _1301_/D VGND VPWR _1302_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_1_clk clkbuf_4_0_0_clk/X VGND VPWR _1336_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1232_ _1233_/CLK _1232_/D VGND VPWR _1233_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1163_ _1163_/CLK _1163_/D VGND VPWR _1164_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_18_560 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1094_ _1104_/CLK _1094_/D VGND VPWR _1095_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0114_ _0743_/CLK _0114_/D VGND VPWR _0115_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_368 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0045_ _0169_/CLK _0045_/D VGND VPWR _0046_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1996_ _1996_/CLK _1996_/D VGND VPWR _1997_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_279 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0947_ _0953_/CLK _0947_/D VGND VPWR _0948_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0878_ _0894_/CLK _0878_/D VGND VPWR _0879_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_16_508 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1850_ _1862_/CLK _1850_/D VGND VPWR _1851_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1781_ _1783_/CLK _1781_/D VGND VPWR _1782_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0801_ _0813_/CLK _0801_/D VGND VPWR _0802_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0732_ _0793_/CLK _0732_/D VGND VPWR _0733_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0663_ _0908_/CLK _0663_/D VGND VPWR _0664_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_41_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0594_ _1649_/CLK _0594_/D VGND VPWR _0605_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1215_ _1228_/CLK _1215_/D VGND VPWR _1216_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1146_ _1162_/CLK _1146_/D VGND VPWR _1147_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_143 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_411 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1077_ _1077_/CLK _1077_/D VGND VPWR _1079_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0028_ _1858_/CLK _0028_/D VGND VPWR _0029_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1979_ _1991_/CLK _1979_/D VGND VPWR _1980_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_23 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_555 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_208 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_154 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1000_ _1010_/CLK _1000_/D VGND VPWR _1002_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_168 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1902_ _1985_/CLK _1902_/D VGND VPWR _1903_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1833_ _1833_/CLK _1833_/D VGND VPWR _1844_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1764_ _1764_/CLK _1764_/D VGND VPWR _1765_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0715_ _1665_/CLK _0715_/D VGND VPWR _0726_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1695_ _1695_/CLK _1695_/D VGND VPWR _1696_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0646_ _0919_/CLK _0646_/D VGND VPWR _0647_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0577_ _0585_/CLK _0577_/D VGND VPWR _0578_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_430 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1129_ _1147_/CLK _1129_/D VGND VPWR _1130_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_173 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_152 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0500_ _0508_/CLK _0500_/D VGND VPWR _0501_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_606 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1480_ _1965_/CLK _1480_/D VGND VPWR _1481_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0431_ _0973_/CLK _0431_/D VGND VPWR _0432_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0362_ _1112_/CLK _0362_/D VGND VPWR _0364_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0293_ _0295_/CLK _0293_/D VGND VPWR _0294_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1816_ _1816_/CLK _1816_/D VGND VPWR _1817_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1747_ _1747_/CLK _1747_/D VGND VPWR _1748_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1678_ _1687_/CLK _1678_/D VGND VPWR _1679_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0629_ _0632_/CLK _0629_/D VGND VPWR _0630_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_466 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_326 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_411 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0980_ _1039_/CLK _0980_/D VGND VPWR _0981_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_12_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1601_ _1611_/CLK _1601_/D VGND VPWR _1602_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1532_ _1578_/CLK _1532_/D VGND VPWR _1533_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1463_ _1687_/CLK _1463_/D VGND VPWR _1464_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0414_ _0622_/CLK _0414_/D VGND VPWR _0415_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1394_ _1754_/CLK _1394_/D VGND VPWR _1395_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0345_ _1181_/CLK _0345_/D VGND VPWR _0346_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0276_ _0280_/CLK _0276_/D VGND VPWR _0277_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_266 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_439 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_300 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0130_ _1138_/CLK _0130_/D VGND VPWR _0131_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0061_ _1185_/CLK _0061_/D VGND VPWR _0062_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0963_ _0966_/CLK _0963_/D VGND VPWR _0964_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0894_ _0894_/CLK _0894_/D VGND VPWR _0895_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_71_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1515_ _1604_/CLK _1515_/D VGND VPWR _1516_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1446_ _1695_/CLK _1446_/D VGND VPWR _1447_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1377_ _1764_/CLK _1377_/D VGND VPWR _1378_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0328_ _1070_/CLK _0328_/D VGND VPWR _0329_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_70_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0259_ _1973_/CLK _0259_/D VGND VPWR _0260_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_255 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1300_ _1348_/CLK _1300_/D VGND VPWR _1301_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1231_ _1233_/CLK _1231_/D VGND VPWR _1232_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_77_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1162_ _1162_/CLK _1162_/D VGND VPWR _1163_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1093_ _1104_/CLK _1093_/D VGND VPWR _1094_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0113_ _0743_/CLK _0113_/D VGND VPWR _0114_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0044_ _1635_/CLK _0044_/D VGND VPWR _0055_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1995_ _1995_/CLK _1995_/D VGND VPWR _1996_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0946_ _1686_/CLK _0946_/D VGND VPWR _0957_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0877_ _0894_/CLK _0877_/D VGND VPWR _0878_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1429_ _1695_/CLK _1429_/D VGND VPWR _1430_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_464 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1780_ _1783_/CLK _1780_/D VGND VPWR _1781_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0800_ _0906_/CLK _0800_/D VGND VPWR _0801_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0731_ _0761_/CLK _0731_/D VGND VPWR _0732_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0662_ _0908_/CLK _0662_/D VGND VPWR _0663_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0593_ _0595_/CLK _0593_/D VGND VPWR _0595_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_239 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1214_ _1228_/CLK _1214_/D VGND VPWR _1215_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1145_ _1147_/CLK _1145_/D VGND VPWR _1146_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_294 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1076_ _1181_/CLK _1076_/D VGND VPWR _1077_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0027_ _1862_/CLK _0027_/D VGND VPWR _0028_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1978_ _1991_/CLK _1978_/D VGND VPWR _1979_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0929_ _0932_/CLK _0929_/D VGND VPWR _0930_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_567 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_442 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_210 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_63 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_559 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1901_ _1985_/CLK _1901_/D VGND VPWR _1902_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_342 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1832_ _1862_/CLK _1832_/D VGND VPWR _1834_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1763_ _1772_/CLK _1763_/D VGND VPWR _1764_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1694_ _1710_/CLK _1694_/D VGND VPWR _1695_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0714_ _1127_/CLK _0714_/D VGND VPWR _0716_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0645_ _0919_/CLK _0645_/D VGND VPWR _0646_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0576_ _0585_/CLK _0576_/D VGND VPWR _0577_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1128_ _1147_/CLK _1128_/D VGND VPWR _1129_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_467 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1059_ _1071_/CLK _1059_/D VGND VPWR _1060_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_420 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_626 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_142 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_175 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0430_ _0953_/CLK _0430_/D VGND VPWR _0431_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0361_ _1112_/CLK _0361_/D VGND VPWR _0362_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0292_ _0316_/CLK _0292_/D VGND VPWR _0293_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_0 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1815_ _1816_/CLK _1815_/D VGND VPWR _1816_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1746_ _1747_/CLK _1746_/D VGND VPWR _1747_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1677_ _1687_/CLK _1677_/D VGND VPWR _1678_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0628_ _0632_/CLK _0628_/D VGND VPWR _0629_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0559_ _0610_/CLK _0559_/D VGND VPWR _0560_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_423 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_415 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1600_ _1600_/CLK _1600_/D VGND VPWR _1601_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_4_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1531_ _1578_/CLK _1531_/D VGND VPWR _1532_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1462_ _1687_/CLK _1462_/D VGND VPWR _1463_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0413_ _0622_/CLK _0413_/D VGND VPWR _0414_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1393_ _1754_/CLK _1393_/D VGND VPWR _1394_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0344_ _1181_/CLK _0344_/D VGND VPWR _0345_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0275_ _0539_/CLK _0275_/D VGND VPWR _0286_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1729_ _1747_/CLK _1729_/D VGND VPWR _1730_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_231 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_407 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0060_ _1170_/CLK _0060_/D VGND VPWR _0061_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_45_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0962_ _0966_/CLK _0962_/D VGND VPWR _0963_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0893_ _0898_/CLK _0893_/D VGND VPWR _0894_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1514_ _1604_/CLK _1514_/D VGND VPWR _1515_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_267 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1445_ _1686_/CLK _1445_/D VGND VPWR _1446_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1376_ _1764_/CLK _1376_/D VGND VPWR _1377_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0327_ _1070_/CLK _0327_/D VGND VPWR _0328_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0258_ _1973_/CLK _0258_/D VGND VPWR _0259_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0189_ _0214_/CLK _0189_/D VGND VPWR _0190_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_11_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_318 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_462 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1230_ _1233_/CLK _1230_/D VGND VPWR _1231_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1161_ _1162_/CLK _1161_/D VGND VPWR _1162_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0112_ _0743_/CLK _0112_/D VGND VPWR _0113_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1092_ _1104_/CLK _1092_/D VGND VPWR _1093_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0043_ _0169_/CLK _0043_/D VGND VPWR _0045_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_45_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1994_ _1995_/CLK _1994_/D VGND VPWR _1995_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0945_ _0953_/CLK _0945_/D VGND VPWR _0947_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0876_ _0894_/CLK _0876_/D VGND VPWR _0877_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1428_ _1794_/CLK _1428_/D VGND VPWR _1429_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_18_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1359_ _1364_/CLK _1359_/D VGND VPWR _1360_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_74_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_167 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_568 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0730_ _0793_/CLK _0730_/D VGND VPWR _0731_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0661_ _0916_/CLK _0661_/D VGND VPWR _0662_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0592_ _0595_/CLK _0592_/D VGND VPWR _0593_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_546 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1213_ _1228_/CLK _1213_/D VGND VPWR _1214_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_77_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1144_ _1841_/CLK _1144_/D VGND VPWR _1155_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1075_ _1181_/CLK _1075_/D VGND VPWR _1076_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_18_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0026_ _1858_/CLK _0026_/D VGND VPWR _0027_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1977_ _1991_/CLK _1977_/D VGND VPWR _1978_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0928_ _0932_/CLK _0928_/D VGND VPWR _0929_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0859_ _0864_/CLK _0859_/D VGND VPWR _0860_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_579 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1900_ _1985_/CLK _1900_/D VGND VPWR _1901_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_354 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1831_ _1846_/CLK _1831_/D VGND VPWR _1832_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_42_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1762_ _1772_/CLK _1762_/D VGND VPWR _1763_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_7_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_583 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1693_ _1695_/CLK _1693_/D VGND VPWR _1694_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0713_ _0793_/CLK _0713_/D VGND VPWR _0714_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0644_ _0919_/CLK _0644_/D VGND VPWR _0645_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0575_ _0585_/CLK _0575_/D VGND VPWR _0576_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1127_ _1127_/CLK _1127_/D VGND VPWR _1128_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1058_ _1071_/CLK _1058_/D VGND VPWR _1059_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_479 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0009_ _1996_/CLK _0009_/D VGND VPWR _0010_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_60_clk clkbuf_4_15_0_clk/X VGND VPWR _0529_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_31_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_143 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_176 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_51_clk clkbuf_4_14_0_clk/X VGND VPWR _1077_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XPHY_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0360_ _1112_/CLK _0360_/D VGND VPWR _0361_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0291_ _0295_/CLK _0291_/D VGND VPWR _0292_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_251 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_593 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_42_clk clkbuf_4_9_0_clk/X VGND VPWR _1088_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1814_ _1814_/CLK _1814_/D VGND VPWR _1815_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1745_ _1747_/CLK _1745_/D VGND VPWR _1746_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1676_ _1687_/CLK _1676_/D VGND VPWR _1677_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0627_ _1665_/CLK _0627_/D VGND VPWR _0638_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0558_ _0610_/CLK _0558_/D VGND VPWR _0559_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_313 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0489_ _0998_/CLK _0489_/D VGND VPWR _0490_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_26_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_446 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_33_clk clkbuf_4_11_0_clk/X VGND VPWR _0906_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_1_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_508 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_24_clk clkbuf_4_8_0_clk/X VGND VPWR _0791_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_40_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1530_ _1578_/CLK _1530_/D VGND VPWR _1531_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1461_ _1710_/CLK _1461_/D VGND VPWR _1462_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1392_ _1754_/CLK _1392_/D VGND VPWR _1393_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0412_ _1077_/CLK _0412_/D VGND VPWR _0413_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0343_ _1181_/CLK _0343_/D VGND VPWR _0344_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0274_ _1010_/CLK _0274_/D VGND VPWR _0276_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_582 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_15_clk clkbuf_4_9_0_clk/X VGND VPWR _1170_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1728_ _1736_/CLK _1728_/D VGND VPWR _1729_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1659_ _1659_/CLK _1659_/D VGND VPWR _1660_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_158 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0961_ _0966_/CLK _0961_/D VGND VPWR _0962_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0892_ _0894_/CLK _0892_/D VGND VPWR _0893_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_57_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1513_ _1587_/CLK _1513_/D VGND VPWR _1514_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1444_ _1686_/CLK _1444_/D VGND VPWR _1445_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_4_clk clkbuf_4_2_0_clk/X VGND VPWR _1272_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1375_ _1764_/CLK _1375_/D VGND VPWR _1376_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0326_ _1071_/CLK _0326_/D VGND VPWR _0327_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0257_ _1973_/CLK _0257_/D VGND VPWR _0258_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0188_ _1858_/CLK _0188_/D VGND VPWR _0189_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_574 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_117 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_535 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_290 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1160_ _1163_/CLK _1160_/D VGND VPWR _1161_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_603 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0111_ _0743_/CLK _0111_/D VGND VPWR _0112_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1091_ _1104_/CLK _1091_/D VGND VPWR _1092_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0042_ _1841_/CLK _0042_/D VGND VPWR _0043_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_45_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1993_ _1997_/CLK _1993_/D VGND VPWR _1994_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0944_ _0953_/CLK _0944_/D VGND VPWR _0945_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0875_ _0894_/CLK _0875_/D VGND VPWR _0876_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1427_ _1794_/CLK _1427_/D VGND VPWR _1428_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1358_ _1364_/CLK _1358_/D VGND VPWR _1359_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1289_ _1348_/CLK _1289_/D VGND VPWR _1290_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_71_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0309_ _1046_/CLK _0309_/D VGND VPWR _0310_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_87 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0660_ _1649_/CLK _0660_/D VGND VPWR _0671_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0591_ _0595_/CLK _0591_/D VGND VPWR _0592_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1212_ _1233_/CLK _1212_/D VGND VPWR _1213_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1143_ _1162_/CLK _1143_/D VGND VPWR _1145_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1074_ _1181_/CLK _1074_/D VGND VPWR _1075_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_499 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0025_ _1858_/CLK _0025_/D VGND VPWR _0026_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_60_182 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1976_ _1987_/CLK _1976_/D VGND VPWR _1987_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0927_ _1077_/CLK _0927_/D VGND VPWR _0928_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0858_ _1665_/CLK _0858_/D VGND VPWR _0869_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0789_ _0791_/CLK _0789_/D VGND VPWR _0790_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1830_ _1862_/CLK _1830_/D VGND VPWR _1831_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1761_ _1772_/CLK _1761_/D VGND VPWR _1762_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1692_ _1695_/CLK _1692_/D VGND VPWR _1693_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0712_ _0793_/CLK _0712_/D VGND VPWR _0713_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_7_595 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0643_ _0919_/CLK _0643_/D VGND VPWR _0644_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0574_ _0585_/CLK _0574_/D VGND VPWR _0575_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1126_ _1127_/CLK _1126_/D VGND VPWR _1127_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_499 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1057_ _1071_/CLK _1057_/D VGND VPWR _1058_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0008_ _1997_/CLK _0008_/D VGND VPWR _0009_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1959_ _1973_/CLK _1959_/D VGND VPWR _1960_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_100 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_166 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_199 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_359 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_86 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0290_ _0295_/CLK _0290_/D VGND VPWR _0291_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_75_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_clk clk VGND VPWR clkbuf_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1813_ _1814_/CLK _1813_/D VGND VPWR _1814_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1744_ _1754_/CLK _1744_/D VGND VPWR _1745_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1675_ _1687_/CLK _1675_/D VGND VPWR _1676_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0626_ _0632_/CLK _0626_/D VGND VPWR _0628_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0557_ _0595_/CLK _0557_/D VGND VPWR _0558_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0488_ _0998_/CLK _0488_/D VGND VPWR _0489_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1109_ _1112_/CLK _1109_/D VGND VPWR _1110_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_620 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_303 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1460_ _1687_/CLK _1460_/D VGND VPWR _1461_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1391_ _1754_/CLK _1391_/D VGND VPWR _1392_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0411_ _0622_/CLK _0411_/D VGND VPWR _0412_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0342_ _1181_/CLK _0342_/D VGND VPWR _0343_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_111 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0273_ _0280_/CLK _0273_/D VGND VPWR _0274_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1727_ _1736_/CLK _1727_/D VGND VPWR _1728_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_227 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1658_ _1659_/CLK _1658_/D VGND VPWR _1659_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0609_ _0610_/CLK _0609_/D VGND VPWR _0610_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1589_ _1592_/CLK _1589_/D VGND VPWR _1590_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_271 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_266 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0960_ _0966_/CLK _0960_/D VGND VPWR _0961_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0891_ _1665_/CLK _0891_/D VGND VPWR _0902_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1512_ _1604_/CLK _1512_/D VGND VPWR _1513_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1443_ _1686_/CLK _1443_/D VGND VPWR _1444_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1374_ _1764_/CLK _1374_/D VGND VPWR _1375_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0325_ _1070_/CLK _0325_/D VGND VPWR _0326_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0256_ _1980_/CLK _0256_/D VGND VPWR _0257_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_70_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0187_ _1635_/CLK _0187_/D VGND VPWR _0198_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_394 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0110_ _1635_/CLK _0110_/D VGND VPWR _0121_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1090_ _1104_/CLK _1090_/D VGND VPWR _1091_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0041_ _1841_/CLK _0041_/D VGND VPWR _0042_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_523 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1992_ _1995_/CLK _1992_/D VGND VPWR _1993_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0943_ _1077_/CLK _0943_/D VGND VPWR _0944_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0874_ _0874_/CLK _0874_/D VGND VPWR _0875_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1426_ _1794_/CLK _1426_/D VGND VPWR _1427_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1357_ _1364_/CLK _1357_/D VGND VPWR _1358_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0308_ _1907_/CLK _0308_/D VGND VPWR _0319_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1288_ _1348_/CLK _1288_/D VGND VPWR _1289_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0239_ _0295_/CLK _0239_/D VGND VPWR _0240_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_43_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_128 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0590_ _0595_/CLK _0590_/D VGND VPWR _0591_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_526 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1211_ _1233_/CLK _1211_/D VGND VPWR _1212_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1142_ _1147_/CLK _1142_/D VGND VPWR _1143_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1073_ _1181_/CLK _1073_/D VGND VPWR _1074_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0024_ _1858_/CLK _0024_/D VGND VPWR _0025_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1975_ _1975_/CLK _1975_/D VGND VPWR _1977_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0926_ _0932_/CLK _0926_/D VGND VPWR _0927_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0857_ _0864_/CLK _0857_/D VGND VPWR _0859_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0788_ _0793_/CLK _0788_/D VGND VPWR _0789_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1409_ _1747_/CLK _1409_/D VGND VPWR _1410_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_191 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_92 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1760_ _1772_/CLK _1760_/D VGND VPWR _1761_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0711_ _1127_/CLK _0711_/D VGND VPWR _0712_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1691_ _1695_/CLK _1691_/D VGND VPWR _1692_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0642_ _0642_/CLK _0642_/D VGND VPWR _0643_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0573_ _0573_/CLK _0573_/D VGND VPWR _0574_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_618 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1125_ _1127_/CLK _1125_/D VGND VPWR _1126_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1056_ _1826_/CLK _1056_/D VGND VPWR _1067_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0007_ _1997_/CLK _0007_/D VGND VPWR _0008_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1958_ _1973_/CLK _1958_/D VGND VPWR _1959_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0909_ _0919_/CLK _0909_/D VGND VPWR _0910_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1889_ _1991_/CLK _1889_/D VGND VPWR _1890_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_172 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_134 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1812_ _1816_/CLK _1812_/D VGND VPWR _1813_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1743_ _1747_/CLK _1743_/D VGND VPWR _1744_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_7_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1674_ _1687_/CLK _1674_/D VGND VPWR _1675_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0625_ _0632_/CLK _0625_/D VGND VPWR _0626_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0556_ _0573_/CLK _0556_/D VGND VPWR _0557_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0487_ _0998_/CLK _0487_/D VGND VPWR _0488_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1108_ _1112_/CLK _1108_/D VGND VPWR _1109_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_587 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1039_ _1039_/CLK _1039_/D VGND VPWR _1040_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_110_clk clkbuf_4_1_0_clk/X VGND VPWR _1794_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_89_610 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_23 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_168 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_101_clk clkbuf_4_4_0_clk/X VGND VPWR _1673_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_4_330 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1390_ _1754_/CLK _1390_/D VGND VPWR _1391_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0410_ _0622_/CLK _0410_/D VGND VPWR _0411_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0341_ _0539_/CLK _0341_/D VGND VPWR _0352_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0272_ _0280_/CLK _0272_/D VGND VPWR _0273_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_50_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_495 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1726_ _1726_/CLK _1726_/D VGND VPWR _1727_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1657_ _1659_/CLK _1657_/D VGND VPWR _1658_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1588_ _1592_/CLK _1588_/D VGND VPWR _1589_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0608_ _0610_/CLK _0608_/D VGND VPWR _0609_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0539_ _0539_/CLK _0539_/D VGND VPWR _0550_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_348 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_138 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_23 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_616 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0890_ _0894_/CLK _0890_/D VGND VPWR _0892_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_43_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1511_ _1604_/CLK _1511_/D VGND VPWR _1512_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1442_ _1686_/CLK _1442_/D VGND VPWR _1443_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1373_ _1373_/CLK _1373_/D VGND VPWR _1374_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0324_ _1071_/CLK _0324_/D VGND VPWR _0325_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_307 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0255_ _1973_/CLK _0255_/D VGND VPWR _0256_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_554 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0186_ _0214_/CLK _0186_/D VGND VPWR _0188_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1709_ _1726_/CLK _1709_/D VGND VPWR _1710_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0040_ _0169_/CLK _0040_/D VGND VPWR _0041_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_72_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1991_ _1991_/CLK _1991_/D VGND VPWR _1992_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0942_ _0953_/CLK _0942_/D VGND VPWR _0943_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_263 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0873_ _0874_/CLK _0873_/D VGND VPWR _0874_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_62_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1425_ _1794_/CLK _1425_/D VGND VPWR _1426_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1356_ _1364_/CLK _1356_/D VGND VPWR _1357_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0307_ _1046_/CLK _0307_/D VGND VPWR _0309_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1287_ _1348_/CLK _1287_/D VGND VPWR _1288_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0238_ _1996_/CLK _0238_/D VGND VPWR _0239_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_90_clk clkbuf_4_5_0_clk/X VGND VPWR _1578_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0169_ _0169_/CLK _0169_/D VGND VPWR _0170_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_378 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_498 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_81_clk clkbuf_4_7_0_clk/X VGND VPWR _1985_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_97_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1210_ _1233_/CLK _1210_/D VGND VPWR _1211_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1141_ _1147_/CLK _1141_/D VGND VPWR _1142_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1072_ _1077_/CLK _1072_/D VGND VPWR _1073_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0023_ _1858_/CLK _0023_/D VGND VPWR _0024_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_72_clk clkbuf_4_12_0_clk/X VGND VPWR _1046_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_33_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1974_ _1980_/CLK _1974_/D VGND VPWR _1975_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0925_ _0932_/CLK _0925_/D VGND VPWR _0926_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0856_ _0864_/CLK _0856_/D VGND VPWR _0857_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0787_ _0813_/CLK _0787_/D VGND VPWR _0788_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1408_ _1710_/CLK _1408_/D VGND VPWR _1409_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_402 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1339_ _1772_/CLK _1339_/D VGND VPWR _1340_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_254 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_63_clk clkbuf_4_15_0_clk/X VGND VPWR _0977_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_61_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_54_clk clkbuf_4_14_0_clk/X VGND VPWR _0610_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_15_376 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0710_ _0793_/CLK _0710_/D VGND VPWR _0711_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1690_ _1695_/CLK _1690_/D VGND VPWR _1691_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0641_ _0642_/CLK _0641_/D VGND VPWR _0642_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0572_ _1649_/CLK _0572_/D VGND VPWR _0583_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1124_ _1127_/CLK _1124_/D VGND VPWR _1125_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1055_ _1055_/CLK _1055_/D VGND VPWR _1057_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_45_clk clkbuf_4_12_0_clk/X VGND VPWR _1178_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0006_ _1997_/CLK _0006_/D VGND VPWR _0007_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_31_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1957_ _1973_/CLK _1957_/D VGND VPWR _1958_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1888_ _1987_/CLK _1888_/D VGND VPWR _1899_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0908_ _0908_/CLK _0908_/D VGND VPWR _0909_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0839_ _0845_/CLK _0839_/D VGND VPWR _0840_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_36_clk clkbuf_4_11_0_clk/X VGND VPWR _0919_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XPHY_124 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_179 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_339 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_368 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_27_clk clkbuf_4_10_0_clk/X VGND VPWR _0831_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_35_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_4 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1811_ _1833_/CLK _1811_/D VGND VPWR _1822_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1742_ _1747_/CLK _1742_/D VGND VPWR _1743_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_7_86 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1673_ _1673_/CLK _1673_/D VGND VPWR _1674_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0624_ _0632_/CLK _0624_/D VGND VPWR _0625_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0555_ _0573_/CLK _0555_/D VGND VPWR _0556_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0486_ _0977_/CLK _0486_/D VGND VPWR _0487_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_26_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1107_ _1112_/CLK _1107_/D VGND VPWR _1108_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_18_clk clkbuf_4_8_0_clk/X VGND VPWR _1127_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1038_ _1039_/CLK _1038_/D VGND VPWR _1039_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_537 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0340_ _1181_/CLK _0340_/D VGND VPWR _0342_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0271_ _0280_/CLK _0271_/D VGND VPWR _0272_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1725_ _1736_/CLK _1725_/D VGND VPWR _1726_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1656_ _1665_/CLK _1656_/D VGND VPWR _1657_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_7_clk clkbuf_4_2_0_clk/X VGND VPWR _1229_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1587_ _1587_/CLK _1587_/D VGND VPWR _1588_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0607_ _0610_/CLK _0607_/D VGND VPWR _0608_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_463 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0538_ _0573_/CLK _0538_/D VGND VPWR _0540_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_102 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0469_ _0508_/CLK _0469_/D VGND VPWR _0470_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_468 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_28 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_408 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_496 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_251 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1510_ _1604_/CLK _1510_/D VGND VPWR _1511_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1441_ _1686_/CLK _1441_/D VGND VPWR _1442_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_4_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1372_ _1764_/CLK _1372_/D VGND VPWR _1373_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0323_ _1071_/CLK _0323_/D VGND VPWR _0324_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0254_ _1973_/CLK _0254_/D VGND VPWR _0255_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_511 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0185_ _1858_/CLK _0185_/D VGND VPWR _0186_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_382 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1708_ _1736_/CLK _1708_/D VGND VPWR _1709_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1639_ _1659_/CLK _1639_/D VGND VPWR _1640_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_411 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1990_ _1991_/CLK _1990_/D VGND VPWR _1991_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0941_ _1077_/CLK _0941_/D VGND VPWR _0942_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_60_399 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_275 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0872_ _0874_/CLK _0872_/D VGND VPWR _0873_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_508 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1424_ _1794_/CLK _1424_/D VGND VPWR _1425_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1355_ _1364_/CLK _1355_/D VGND VPWR _1356_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0306_ _1033_/CLK _0306_/D VGND VPWR _0307_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1286_ _1336_/CLK _1286_/D VGND VPWR _1287_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_71_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0237_ _0295_/CLK _0237_/D VGND VPWR _0238_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0168_ _0169_/CLK _0168_/D VGND VPWR _0169_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0099_ _1635_/CLK _0099_/D VGND VPWR _0110_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_506 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1140_ _1147_/CLK _1140_/D VGND VPWR _1141_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1071_ _1071_/CLK _1071_/D VGND VPWR _1072_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0022_ _1965_/CLK _0022_/D VGND VPWR _0033_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1973_ _1973_/CLK _1973_/D VGND VPWR _1974_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0924_ _1826_/CLK _0924_/D VGND VPWR _0935_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0855_ _0864_/CLK _0855_/D VGND VPWR _0856_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0786_ _0791_/CLK _0786_/D VGND VPWR _0787_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1407_ _1710_/CLK _1407_/D VGND VPWR _1408_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_414 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1338_ _1772_/CLK _1338_/D VGND VPWR _1339_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1269_ _1272_/CLK _1269_/D VGND VPWR _1270_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_45_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0640_ _0642_/CLK _0640_/D VGND VPWR _0641_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0571_ _0573_/CLK _0571_/D VGND VPWR _0573_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_18_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1123_ _1127_/CLK _1123_/D VGND VPWR _1124_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1054_ _1055_/CLK _1054_/D VGND VPWR _1055_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0005_ _1997_/CLK _0005_/D VGND VPWR _0006_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_196 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1956_ _1956_/CLK _1956_/D VGND VPWR _1957_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0907_ _0919_/CLK _0907_/D VGND VPWR _0908_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1887_ _1991_/CLK _1887_/D VGND VPWR _1889_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0838_ _0845_/CLK _0838_/D VGND VPWR _0839_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0769_ _0791_/CLK _0769_/D VGND VPWR _0771_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_491 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_158 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_78 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_5 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1810_ _1816_/CLK _1810_/D VGND VPWR _1812_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1741_ _1747_/CLK _1741_/D VGND VPWR _1742_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1672_ _1687_/CLK _1672_/D VGND VPWR _1673_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0623_ _0632_/CLK _0623_/D VGND VPWR _0624_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0554_ _0595_/CLK _0554_/D VGND VPWR _0555_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0485_ _0998_/CLK _0485_/D VGND VPWR _0486_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_66_520 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1106_ _1112_/CLK _1106_/D VGND VPWR _1107_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1037_ _1039_/CLK _1037_/D VGND VPWR _1038_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_41_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1939_ _1975_/CLK _1939_/D VGND VPWR _1940_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_411 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_111 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_339 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0270_ _1010_/CLK _0270_/D VGND VPWR _0271_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_228 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1724_ _1833_/CLK _1724_/D VGND VPWR _1725_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1655_ _1659_/CLK _1655_/D VGND VPWR _1656_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1586_ _1587_/CLK _1586_/D VGND VPWR _1587_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0606_ _0610_/CLK _0606_/D VGND VPWR _0607_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0537_ _0573_/CLK _0537_/D VGND VPWR _0538_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0468_ _0529_/CLK _0468_/D VGND VPWR _0469_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0399_ _0642_/CLK _0399_/D VGND VPWR _0400_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_379 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1440_ _1814_/CLK _1440_/D VGND VPWR _1441_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_4_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1371_ _1373_/CLK _1371_/D VGND VPWR _1372_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0322_ _1055_/CLK _0322_/D VGND VPWR _0323_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0253_ _1594_/CLK _0253_/D VGND VPWR _0264_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0184_ _0214_/CLK _0184_/D VGND VPWR _0185_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_523 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_191 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1707_ _1710_/CLK _1707_/D VGND VPWR _1708_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1638_ _1659_/CLK _1638_/D VGND VPWR _1639_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1569_ _1594_/CLK _1569_/D VGND VPWR _1570_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_27_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_320 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0940_ _0953_/CLK _0940_/D VGND VPWR _0941_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_41_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0871_ _0874_/CLK _0871_/D VGND VPWR _0872_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_482 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1423_ _1695_/CLK _1423_/D VGND VPWR _1424_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1354_ _1364_/CLK _1354_/D VGND VPWR _1355_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1285_ _1348_/CLK _1285_/D VGND VPWR _1286_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_28_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0305_ _1046_/CLK _0305_/D VGND VPWR _0306_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0236_ _1980_/CLK _0236_/D VGND VPWR _0237_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0167_ _0169_/CLK _0167_/D VGND VPWR _0168_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0098_ _1226_/CLK _0098_/D VGND VPWR _0100_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_358 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_478 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_117 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_515 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_518 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_391 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1070_ _1070_/CLK _1070_/D VGND VPWR _1071_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0021_ _1858_/CLK _0021_/D VGND VPWR _0023_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1972_ _1975_/CLK _1972_/D VGND VPWR _1973_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0923_ _0932_/CLK _0923_/D VGND VPWR _0925_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0854_ _0874_/CLK _0854_/D VGND VPWR _0855_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0785_ _0813_/CLK _0785_/D VGND VPWR _0786_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1406_ _1747_/CLK _1406_/D VGND VPWR _1407_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1337_ _1772_/CLK _1337_/D VGND VPWR _1338_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1268_ _1272_/CLK _1268_/D VGND VPWR _1269_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0219_ _0316_/CLK _0219_/D VGND VPWR _0221_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_43_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1199_ _1808_/CLK _1199_/D VGND VPWR _1200_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_356 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0570_ _0573_/CLK _0570_/D VGND VPWR _0571_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_93_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1122_ _1841_/CLK _1122_/D VGND VPWR _1133_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_93_587 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1053_ _1055_/CLK _1053_/D VGND VPWR _1054_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0004_ _1997_/CLK _0004_/D VGND VPWR _0005_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_142 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1955_ _1956_/CLK _1955_/D VGND VPWR _1956_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0906_ _0906_/CLK _0906_/D VGND VPWR _0907_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1886_ _1985_/CLK _1886_/D VGND VPWR _1887_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0837_ _0845_/CLK _0837_/D VGND VPWR _0838_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0768_ _0791_/CLK _0768_/D VGND VPWR _0769_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0699_ _0906_/CLK _0699_/D VGND VPWR _0700_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_159 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_113_clk clkbuf_4_1_0_clk/X VGND VPWR _1736_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_21_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_502 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_6 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_579 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_104_clk clkbuf_4_6_0_clk/X VGND VPWR _1827_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1740_ _1747_/CLK _1740_/D VGND VPWR _1741_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1671_ _1673_/CLK _1671_/D VGND VPWR _1672_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0622_ _0622_/CLK _0622_/D VGND VPWR _0623_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0553_ _0573_/CLK _0553_/D VGND VPWR _0554_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0484_ _1985_/CLK _0484_/D VGND VPWR _0495_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1105_ _1112_/CLK _1105_/D VGND VPWR _1106_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1036_ _1046_/CLK _1036_/D VGND VPWR _1037_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1938_ _1956_/CLK _1938_/D VGND VPWR _1939_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1869_ _1995_/CLK _1869_/D VGND VPWR _1870_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_423 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_178 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_440 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1723_ _1726_/CLK _1723_/D VGND VPWR _1724_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1654_ _1659_/CLK _1654_/D VGND VPWR _1655_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1585_ _1592_/CLK _1585_/D VGND VPWR _1586_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0605_ _1649_/CLK _0605_/D VGND VPWR _0616_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0536_ _1182_/CLK _0536_/D VGND VPWR _0537_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0467_ _0529_/CLK _0467_/D VGND VPWR _0468_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_448 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0398_ _0642_/CLK _0398_/D VGND VPWR _0399_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1019_ _1039_/CLK _1019_/D VGND VPWR _1020_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1370_ _1373_/CLK _1370_/D VGND VPWR _1371_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0321_ _1070_/CLK _0321_/D VGND VPWR _0322_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_148 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0252_ _1980_/CLK _0252_/D VGND VPWR _0254_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0183_ _1178_/CLK _0183_/D VGND VPWR _0184_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1706_ _1710_/CLK _1706_/D VGND VPWR _1707_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1637_ _1659_/CLK _1637_/D VGND VPWR _1638_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_240 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1568_ _1592_/CLK _1568_/D VGND VPWR _1569_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1499_ _1604_/CLK _1499_/D VGND VPWR _1500_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0519_ _0529_/CLK _0519_/D VGND VPWR _0520_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_93_clk clkbuf_4_5_0_clk/X VGND VPWR _1611_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_54_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_84_clk clkbuf_4_7_0_clk/X VGND VPWR _1956_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_72_173 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_346 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0870_ _0874_/CLK _0870_/D VGND VPWR _0871_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_70_71 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_494 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1422_ _1695_/CLK _1422_/D VGND VPWR _1423_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1353_ _1373_/CLK _1353_/D VGND VPWR _1354_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1284_ _1348_/CLK _1284_/D VGND VPWR _1285_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0304_ _1046_/CLK _0304_/D VGND VPWR _0305_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0235_ _1996_/CLK _0235_/D VGND VPWR _0236_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_75_clk clkbuf_4_12_0_clk/X VGND VPWR _0214_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_48_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0166_ _1180_/CLK _0166_/D VGND VPWR _0167_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0097_ _1226_/CLK _0097_/D VGND VPWR _0098_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0999_ _1010_/CLK _0999_/D VGND VPWR _1000_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_66_clk clkbuf_4_13_0_clk/X VGND VPWR _1010_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_15_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_57_clk clkbuf_4_15_0_clk/X VGND VPWR _0585_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_65_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0020_ _1858_/CLK _0020_/D VGND VPWR _0021_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_313 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1971_ _1973_/CLK _1971_/D VGND VPWR _1972_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0922_ _0932_/CLK _0922_/D VGND VPWR _0923_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0853_ _0874_/CLK _0853_/D VGND VPWR _0854_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_60_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0784_ _0831_/CLK _0784_/D VGND VPWR _0785_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1405_ _1747_/CLK _1405_/D VGND VPWR _1406_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1336_ _1336_/CLK _1336_/D VGND VPWR _1337_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xinput1 din VGND VPWR input1/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_1267_ _1272_/CLK _1267_/D VGND VPWR _1268_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_48_clk clkbuf_4_12_0_clk/X VGND VPWR _1055_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0218_ _1996_/CLK _0218_/D VGND VPWR _0219_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1198_ _1233_/CLK _1198_/D VGND VPWR _1199_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0149_ _1170_/CLK _0149_/D VGND VPWR _0150_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_39_clk clkbuf_4_11_0_clk/X VGND VPWR _1104_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_74_246 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_294 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1121_ _1127_/CLK _1121_/D VGND VPWR _1123_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1052_ _1055_/CLK _1052_/D VGND VPWR _1053_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_46_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0003_ _1997_/CLK _0003_/D VGND VPWR _0004_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1954_ _1987_/CLK _1954_/D VGND VPWR _1965_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0905_ _0908_/CLK _0905_/D VGND VPWR _0906_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1885_ _1985_/CLK _1885_/D VGND VPWR _1886_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0836_ _1827_/CLK _0836_/D VGND VPWR _0847_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0767_ _0791_/CLK _0767_/D VGND VPWR _0768_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0698_ _1103_/CLK _0698_/D VGND VPWR _0699_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1319_ _1788_/CLK _1319_/D VGND VPWR _1320_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_471 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_87 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_622 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1670_ _1673_/CLK _1670_/D VGND VPWR _1671_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0621_ _0622_/CLK _0621_/D VGND VPWR _0622_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0552_ _0573_/CLK _0552_/D VGND VPWR _0553_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0483_ _0998_/CLK _0483_/D VGND VPWR _0485_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1104_ _1104_/CLK _1104_/D VGND VPWR _1105_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_93_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1035_ _1046_/CLK _1035_/D VGND VPWR _1036_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1937_ _1956_/CLK _1937_/D VGND VPWR _1938_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1868_ _1995_/CLK _1868_/D VGND VPWR _1869_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0819_ _0898_/CLK _0819_/D VGND VPWR _0820_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1799_ _1808_/CLK _1799_/D VGND VPWR _1801_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_102 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_580 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1722_ _1736_/CLK _1722_/D VGND VPWR _1723_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1653_ _1659_/CLK _1653_/D VGND VPWR _1654_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0604_ _0610_/CLK _0604_/D VGND VPWR _0606_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1584_ _1587_/CLK _1584_/D VGND VPWR _1585_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0535_ _0573_/CLK _0535_/D VGND VPWR _0536_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0466_ _1182_/CLK _0466_/D VGND VPWR _0467_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0397_ _0642_/CLK _0397_/D VGND VPWR _0398_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1018_ _1039_/CLK _1018_/D VGND VPWR _1019_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_41_219 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_359 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0320_ _1055_/CLK _0320_/D VGND VPWR _0321_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0251_ _1973_/CLK _0251_/D VGND VPWR _0252_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_119 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0182_ _1178_/CLK _0182_/D VGND VPWR _0183_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_70 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1705_ _1726_/CLK _1705_/D VGND VPWR _1706_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1636_ _1673_/CLK _1636_/D VGND VPWR _1637_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1567_ _1594_/CLK _1567_/D VGND VPWR _1568_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0518_ _0529_/CLK _0518_/D VGND VPWR _0519_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_59_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1498_ _1600_/CLK _1498_/D VGND VPWR _1499_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0449_ _0585_/CLK _0449_/D VGND VPWR _0450_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_358 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1421_ _1783_/CLK _1421_/D VGND VPWR _1422_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1352_ _1364_/CLK _1352_/D VGND VPWR _1353_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_211 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1283_ _1348_/CLK _1283_/D VGND VPWR _1284_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0303_ _1046_/CLK _0303_/D VGND VPWR _0304_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_439 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0234_ _0316_/CLK _0234_/D VGND VPWR _0235_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0165_ _1635_/CLK _0165_/D VGND VPWR _0176_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0096_ _1226_/CLK _0096_/D VGND VPWR _0097_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0998_ _0998_/CLK _0998_/D VGND VPWR _0999_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1619_ _1673_/CLK _1619_/D VGND VPWR _1620_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_594 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_288 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_38 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1970_ _1980_/CLK _1970_/D VGND VPWR _1971_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0921_ _0932_/CLK _0921_/D VGND VPWR _0922_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_81_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0852_ _0874_/CLK _0852_/D VGND VPWR _0853_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0783_ _0831_/CLK _0783_/D VGND VPWR _0784_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1404_ _1747_/CLK _1404_/D VGND VPWR _1405_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1335_ _1336_/CLK _1335_/D VGND VPWR _1336_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1266_ _1320_/CLK _1266_/D VGND VPWR _1267_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0217_ _0316_/CLK _0217_/D VGND VPWR _0218_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1197_ _1808_/CLK _1197_/D VGND VPWR _1198_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0148_ _1162_/CLK _0148_/D VGND VPWR _0149_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0079_ _1228_/CLK _0079_/D VGND VPWR _0080_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_428 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_280 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1120_ _1127_/CLK _1120_/D VGND VPWR _1121_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_93_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1051_ _1055_/CLK _1051_/D VGND VPWR _1052_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0002_ _1997_/CLK _0002_/D VGND VPWR _0003_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_46_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1953_ _1956_/CLK _1953_/D VGND VPWR _1955_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0904_ _0908_/CLK _0904_/D VGND VPWR _0905_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1884_ _1985_/CLK _1884_/D VGND VPWR _1885_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0835_ _0845_/CLK _0835_/D VGND VPWR _0837_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0766_ _0791_/CLK _0766_/D VGND VPWR _0767_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0697_ _0906_/CLK _0697_/D VGND VPWR _0698_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1318_ _1794_/CLK _1318_/D VGND VPWR _1319_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1249_ _1272_/CLK _1249_/D VGND VPWR _1250_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_411 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_8 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0620_ _0622_/CLK _0620_/D VGND VPWR _0621_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0551_ _0573_/CLK _0551_/D VGND VPWR _0552_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_158 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0482_ _0977_/CLK _0482_/D VGND VPWR _0483_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1103_ _1103_/CLK _1103_/D VGND VPWR _1104_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1034_ _1814_/CLK _1034_/D VGND VPWR _1045_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1936_ _1936_/CLK _1936_/D VGND VPWR _1937_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1867_ _1995_/CLK _1867_/D VGND VPWR _1868_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0818_ _0898_/CLK _0818_/D VGND VPWR _0819_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1798_ _1808_/CLK _1798_/D VGND VPWR _1799_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0749_ _0761_/CLK _0749_/D VGND VPWR _0750_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_158 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_607 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_320 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1721_ _1726_/CLK _1721_/D VGND VPWR _1722_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1652_ _1659_/CLK _1652_/D VGND VPWR _1653_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0603_ _0610_/CLK _0603_/D VGND VPWR _0604_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1583_ _1587_/CLK _1583_/D VGND VPWR _1584_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0534_ _1182_/CLK _0534_/D VGND VPWR _0535_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0465_ _0529_/CLK _0465_/D VGND VPWR _0466_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0396_ _1907_/CLK _0396_/D VGND VPWR _0407_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_93_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1017_ _1017_/CLK _1017_/D VGND VPWR _1018_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_62_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1919_ _1936_/CLK _1919_/D VGND VPWR _1920_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_110 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0250_ _1980_/CLK _0250_/D VGND VPWR _0251_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_75_150 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0181_ _1178_/CLK _0181_/D VGND VPWR _0182_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_90_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1704_ _1710_/CLK _1704_/D VGND VPWR _1705_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1635_ _1635_/CLK _1635_/D VGND VPWR _1636_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1566_ _1592_/CLK _1566_/D VGND VPWR _1567_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0517_ _0539_/CLK _0517_/D VGND VPWR _0528_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1497_ _1604_/CLK _1497_/D VGND VPWR _1498_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0448_ _0585_/CLK _0448_/D VGND VPWR _0449_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0379_ _1103_/CLK _0379_/D VGND VPWR _0380_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_66_183 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_186 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_326 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1420_ _1783_/CLK _1420_/D VGND VPWR _1421_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1351_ _1364_/CLK _1351_/D VGND VPWR _1352_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0302_ _1046_/CLK _0302_/D VGND VPWR _0303_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1282_ _1348_/CLK _1282_/D VGND VPWR _1283_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0233_ _1996_/CLK _0233_/D VGND VPWR _0234_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0164_ _0169_/CLK _0164_/D VGND VPWR _0166_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_172 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0095_ _1226_/CLK _0095_/D VGND VPWR _0096_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0997_ _0998_/CLK _0997_/D VGND VPWR _0998_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1618_ _1965_/CLK _1618_/D VGND VPWR _1619_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1549_ _1918_/CLK _1549_/D VGND VPWR _1550_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_212 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_95 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0920_ _0932_/CLK _0920_/D VGND VPWR _0921_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_81_50 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0851_ _0874_/CLK _0851_/D VGND VPWR _0852_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0782_ _0831_/CLK _0782_/D VGND VPWR _0783_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1403_ _1747_/CLK _1403_/D VGND VPWR _1404_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1334_ _1336_/CLK _1334_/D VGND VPWR _1335_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1265_ _1320_/CLK _1265_/D VGND VPWR _1266_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0216_ _0316_/CLK _0216_/D VGND VPWR _0217_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1196_ _1228_/CLK _1196_/D VGND VPWR _1197_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0147_ _1162_/CLK _0147_/D VGND VPWR _0148_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_175 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0078_ _1228_/CLK _0078_/D VGND VPWR _0079_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_10_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_626 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_68 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_554 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_621 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_226 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_116_clk clkbuf_4_1_0_clk/X VGND VPWR _1783_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_23_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1050_ _1055_/CLK _1050_/D VGND VPWR _1051_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_270 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0001_ _1997_/CLK _1997_/Q VGND VPWR _0002_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_18_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1952_ _1956_/CLK _1952_/D VGND VPWR _1953_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_107_clk clkbuf_4_3_0_clk/X VGND VPWR _1826_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0903_ _0908_/CLK _0903_/D VGND VPWR _0904_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1883_ _1985_/CLK _1883_/D VGND VPWR _1884_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0834_ _0845_/CLK _0834_/D VGND VPWR _0835_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0765_ _0791_/CLK _0765_/D VGND VPWR _0766_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0696_ _0906_/CLK _0696_/D VGND VPWR _0697_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1317_ _1320_/CLK _1317_/D VGND VPWR _1318_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1248_ _1272_/CLK _1248_/D VGND VPWR _1249_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1179_ _1180_/CLK _1179_/D VGND VPWR _1180_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_384 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_34 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_462 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_9 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0550_ _1649_/CLK _0550_/D VGND VPWR _0561_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0481_ _0977_/CLK _0481_/D VGND VPWR _0482_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1102_ _1104_/CLK _1102_/D VGND VPWR _1103_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1033_ _1033_/CLK _1033_/D VGND VPWR _1035_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_81_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1935_ _1956_/CLK _1935_/D VGND VPWR _1936_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1866_ _1987_/CLK _1866_/D VGND VPWR _1877_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0817_ _0831_/CLK _0817_/D VGND VPWR _0818_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1797_ _1808_/CLK _1797_/D VGND VPWR _1798_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0748_ _1827_/CLK _0748_/D VGND VPWR _0759_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0679_ _0898_/CLK _0679_/D VGND VPWR _0680_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_354 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_410 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1720_ _1833_/CLK _1720_/D VGND VPWR _1721_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_11_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1651_ _1659_/CLK _1651_/D VGND VPWR _1652_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0602_ _0610_/CLK _0602_/D VGND VPWR _0603_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1582_ _1592_/CLK _1582_/D VGND VPWR _1583_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_380 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0533_ _1182_/CLK _0533_/D VGND VPWR _0534_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0464_ _1182_/CLK _0464_/D VGND VPWR _0465_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0395_ _0642_/CLK _0395_/D VGND VPWR _0397_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_93_162 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1016_ _1017_/CLK _1016_/D VGND VPWR _1017_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1918_ _1918_/CLK _1918_/D VGND VPWR _1919_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1849_ _1862_/CLK _1849_/D VGND VPWR _1850_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_78_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_96_clk clkbuf_4_4_0_clk/X VGND VPWR _1965_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_53_593 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_490 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_20_clk clkbuf_4_8_0_clk/X VGND VPWR _1138_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_4_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_87_clk clkbuf_4_7_0_clk/X VGND VPWR _1907_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_75_162 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0180_ _1178_/CLK _0180_/D VGND VPWR _0181_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_590 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_11_clk clkbuf_4_3_0_clk/X VGND VPWR _1816_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_8_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1703_ _1736_/CLK _1703_/D VGND VPWR _1704_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1634_ _1673_/CLK _1634_/D VGND VPWR _1635_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1565_ _1594_/CLK _1565_/D VGND VPWR _1566_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0516_ _0529_/CLK _0516_/D VGND VPWR _0518_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1496_ _1600_/CLK _1496_/D VGND VPWR _1497_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0447_ _0973_/CLK _0447_/D VGND VPWR _0448_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_78_clk clkbuf_4_6_0_clk/X VGND VPWR _1995_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_27_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0378_ _1103_/CLK _0378_/D VGND VPWR _0379_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_81_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_582 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_69_clk clkbuf_4_13_0_clk/X VGND VPWR _1980_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_85_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1350_ _1373_/CLK _1350_/D VGND VPWR _1351_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0301_ _1046_/CLK _0301_/D VGND VPWR _0302_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1281_ _1348_/CLK _1281_/D VGND VPWR _1282_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_191 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_0_clk clkbuf_4_0_0_clk/X VGND VPWR _1348_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0232_ _1996_/CLK _0232_/D VGND VPWR _0233_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0163_ _0169_/CLK _0163_/D VGND VPWR _0164_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_91_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0094_ _1226_/CLK _0094_/D VGND VPWR _0095_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0996_ _1017_/CLK _0996_/D VGND VPWR _0997_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1617_ _1833_/CLK _1617_/D VGND VPWR _1618_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1548_ _1592_/CLK _1548_/D VGND VPWR _1549_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1479_ _1833_/CLK _1479_/D VGND VPWR _1480_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_59_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_302 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0850_ _0864_/CLK _0850_/D VGND VPWR _0851_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0781_ _1827_/CLK _0781_/D VGND VPWR _0792_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1402_ _1747_/CLK _1402_/D VGND VPWR _1403_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1333_ _1336_/CLK _1333_/D VGND VPWR _1334_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1264_ _1320_/CLK _1264_/D VGND VPWR _1265_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_216 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0215_ _0316_/CLK _0215_/D VGND VPWR _0216_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_611 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1195_ _1816_/CLK _1195_/D VGND VPWR _1196_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0146_ _1162_/CLK _0146_/D VGND VPWR _0147_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0077_ _1635_/CLK _0077_/D VGND VPWR _0088_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_338 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0979_ _1826_/CLK _0979_/D VGND VPWR _0990_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_316 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_168 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0000_ _1965_/CLK _1987_/Q VGND VPWR _0011_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1951_ _1975_/CLK _1951_/D VGND VPWR _1952_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0902_ _1827_/CLK _0902_/D VGND VPWR _0913_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1882_ _1985_/CLK _1882_/D VGND VPWR _1883_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0833_ _0845_/CLK _0833_/D VGND VPWR _0834_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0764_ _0791_/CLK _0764_/D VGND VPWR _0765_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0695_ _0906_/CLK _0695_/D VGND VPWR _0696_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1316_ _1808_/CLK _1316_/D VGND VPWR _1317_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1247_ _1272_/CLK _1247_/D VGND VPWR _1248_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1178_ _1178_/CLK _1178_/D VGND VPWR _1179_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0129_ _1138_/CLK _0129_/D VGND VPWR _0130_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_119 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0480_ _0977_/CLK _0480_/D VGND VPWR _0481_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_138 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1101_ _1103_/CLK _1101_/D VGND VPWR _1102_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1032_ _1046_/CLK _1032_/D VGND VPWR _1033_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1934_ _1956_/CLK _1934_/D VGND VPWR _1935_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1865_ _1995_/CLK _1865_/D VGND VPWR _1867_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1796_ _1814_/CLK _1796_/D VGND VPWR _1797_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0816_ _0898_/CLK _0816_/D VGND VPWR _0817_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0747_ _0750_/CLK _0747_/D VGND VPWR _0749_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0678_ _0898_/CLK _0678_/D VGND VPWR _0679_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_300 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1650_ _1659_/CLK _1650_/D VGND VPWR _1651_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1581_ _1587_/CLK _1581_/D VGND VPWR _1582_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0601_ _0610_/CLK _0601_/D VGND VPWR _0602_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0532_ _1182_/CLK _0532_/D VGND VPWR _0533_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0463_ _1182_/CLK _0463_/D VGND VPWR _0464_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0394_ _0642_/CLK _0394_/D VGND VPWR _0395_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1015_ _1017_/CLK _1015_/D VGND VPWR _1016_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1917_ _1936_/CLK _1917_/D VGND VPWR _1918_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_8_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1848_ _1862_/CLK _1848_/D VGND VPWR _1849_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1779_ _1783_/CLK _1779_/D VGND VPWR _1780_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_391 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_602 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_130 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1702_ _1710_/CLK _1702_/D VGND VPWR _1703_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1633_ _1659_/CLK _1633_/D VGND VPWR _1634_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1564_ _1594_/CLK _1564_/D VGND VPWR _1565_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1495_ _1600_/CLK _1495_/D VGND VPWR _1496_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0515_ _0529_/CLK _0515_/D VGND VPWR _0516_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_406 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0446_ _0973_/CLK _0446_/D VGND VPWR _0447_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_27_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0377_ _1103_/CLK _0377_/D VGND VPWR _0378_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_303 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0300_ _1046_/CLK _0300_/D VGND VPWR _0301_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1280_ _1348_/CLK _1280_/D VGND VPWR _1281_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0231_ _1594_/CLK _0231_/D VGND VPWR _0242_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0162_ _0169_/CLK _0162_/D VGND VPWR _0163_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_155 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0093_ _1226_/CLK _0093_/D VGND VPWR _0094_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0995_ _1017_/CLK _0995_/D VGND VPWR _0996_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_8_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1616_ _1987_/CLK _1616_/D VGND VPWR _1617_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1547_ _1578_/CLK _1547_/D VGND VPWR _1548_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1478_ _1726_/CLK _1478_/D VGND VPWR _1479_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0429_ _0539_/CLK _0429_/D VGND VPWR _0440_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_542 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_350 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_214 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_155 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_30 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0780_ _0831_/CLK _0780_/D VGND VPWR _0782_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1401_ _1747_/CLK _1401_/D VGND VPWR _1402_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1332_ _1336_/CLK _1332_/D VGND VPWR _1333_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1263_ _1302_/CLK _1263_/D VGND VPWR _1264_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0214_ _0214_/CLK _0214_/D VGND VPWR _0215_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1194_ _1816_/CLK _1194_/D VGND VPWR _1195_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_91_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0145_ _1162_/CLK _0145_/D VGND VPWR _0146_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0076_ _1185_/CLK _0076_/D VGND VPWR _0078_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_383 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0978_ _1039_/CLK _0978_/D VGND VPWR _0980_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_534 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_328 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_250 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1950_ _1975_/CLK _1950_/D VGND VPWR _1951_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0901_ _0906_/CLK _0901_/D VGND VPWR _0903_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1881_ _1985_/CLK _1881_/D VGND VPWR _1882_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0832_ _0845_/CLK _0832_/D VGND VPWR _0833_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0763_ _0791_/CLK _0763_/D VGND VPWR _0764_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0694_ _0906_/CLK _0694_/D VGND VPWR _0695_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1315_ _1808_/CLK _1315_/D VGND VPWR _1316_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1246_ _1272_/CLK _1246_/D VGND VPWR _1247_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_442 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1177_ _1841_/CLK _1177_/D VGND VPWR _1184_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0128_ _1138_/CLK _0128_/D VGND VPWR _0129_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0059_ _1170_/CLK _0059_/D VGND VPWR _0060_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_75_548 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_607 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_618 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_9_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_9_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_87_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1100_ _1846_/CLK _1100_/D VGND VPWR _1111_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1031_ _1033_/CLK _1031_/D VGND VPWR _1032_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1933_ _1956_/CLK _1933_/D VGND VPWR _1934_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1864_ _1997_/CLK _1864_/D VGND VPWR _1865_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0815_ _0898_/CLK _0815_/D VGND VPWR _0816_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1795_ _1814_/CLK _1795_/D VGND VPWR _1796_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0746_ _0761_/CLK _0746_/D VGND VPWR _0747_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0677_ _0898_/CLK _0677_/D VGND VPWR _0678_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_334 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1229_ _1229_/CLK _1229_/D VGND VPWR _1230_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_456 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1580_ _1587_/CLK _1580_/D VGND VPWR _1581_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0600_ _0610_/CLK _0600_/D VGND VPWR _0601_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0531_ _1182_/CLK _0531_/D VGND VPWR _0532_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0462_ _0539_/CLK _0462_/D VGND VPWR _0473_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0393_ _0932_/CLK _0393_/D VGND VPWR _0394_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_621 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1014_ _1017_/CLK _1014_/D VGND VPWR _1015_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1916_ _1918_/CLK _1916_/D VGND VPWR _1917_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1847_ _1862_/CLK _1847_/D VGND VPWR _1848_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1778_ _1833_/CLK _1778_/D VGND VPWR _1789_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0729_ _0761_/CLK _0729_/D VGND VPWR _0730_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_72_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_470 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_356 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1701_ _1710_/CLK _1701_/D VGND VPWR _1702_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1632_ _1673_/CLK _1632_/D VGND VPWR _1633_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1563_ _1594_/CLK _1563_/D VGND VPWR _1564_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1494_ _1600_/CLK _1494_/D VGND VPWR _1495_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0514_ _0529_/CLK _0514_/D VGND VPWR _0515_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0445_ _0973_/CLK _0445_/D VGND VPWR _0446_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0376_ _1103_/CLK _0376_/D VGND VPWR _0377_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0230_ _1996_/CLK _0230_/D VGND VPWR _0232_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0161_ _0169_/CLK _0161_/D VGND VPWR _0162_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0092_ _1226_/CLK _0092_/D VGND VPWR _0093_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0994_ _0998_/CLK _0994_/D VGND VPWR _0995_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1615_ _1833_/CLK _1615_/D VGND VPWR _1616_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1546_ _1918_/CLK _1546_/D VGND VPWR _1547_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_59_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1477_ _1833_/CLK _1477_/D VGND VPWR _1478_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0428_ _0973_/CLK _0428_/D VGND VPWR _0430_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0359_ _1112_/CLK _0359_/D VGND VPWR _0360_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_554 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_119_clk clkbuf_4_0_0_clk/X VGND VPWR _1764_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_60_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1400_ _1754_/CLK _1400_/D VGND VPWR _1401_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_502 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1331_ _1336_/CLK _1331_/D VGND VPWR _1332_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1262_ _1302_/CLK _1262_/D VGND VPWR _1263_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0213_ _0316_/CLK _0213_/D VGND VPWR _0214_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1193_ _1808_/CLK _1193_/D VGND VPWR _1194_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0144_ _1162_/CLK _0144_/D VGND VPWR _0145_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0075_ _1185_/CLK _0075_/D VGND VPWR _0076_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_395 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0977_ _0977_/CLK _0977_/D VGND VPWR _0978_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1529_ _1578_/CLK _1529_/D VGND VPWR _1530_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0900_ _0908_/CLK _0900_/D VGND VPWR _0901_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_90 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1880_ _1995_/CLK _1880_/D VGND VPWR _1881_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_41_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0831_ _0831_/CLK _0831_/D VGND VPWR _0832_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0762_ _0791_/CLK _0762_/D VGND VPWR _0763_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0693_ _1665_/CLK _0693_/D VGND VPWR _0704_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_44_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1314_ _1320_/CLK _1314_/D VGND VPWR _1315_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_387 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_270 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1245_ _1272_/CLK _1245_/D VGND VPWR _1246_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1176_ _1180_/CLK _1176_/D VGND VPWR _1178_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0127_ _1138_/CLK _0127_/D VGND VPWR _0128_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0058_ _1185_/CLK _0058_/D VGND VPWR _0059_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_78 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_50_clk clkbuf_4_14_0_clk/X VGND VPWR _0953_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_11_387 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_324 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1030_ _1033_/CLK _1030_/D VGND VPWR _1031_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_468 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1932_ _1965_/CLK _1932_/D VGND VPWR _1943_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_41_clk clkbuf_4_9_0_clk/X VGND VPWR _1112_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_61_298 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1863_ _1995_/CLK _1863_/D VGND VPWR _1864_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0814_ _1827_/CLK _0814_/D VGND VPWR _0825_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1794_ _1794_/CLK _1794_/D VGND VPWR _1795_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0745_ _0750_/CLK _0745_/D VGND VPWR _0746_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0676_ _0898_/CLK _0676_/D VGND VPWR _0677_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1228_ _1228_/CLK _1228_/D VGND VPWR _1229_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_16_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1159_ _1162_/CLK _1159_/D VGND VPWR _1160_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_32_clk clkbuf_4_10_0_clk/X VGND VPWR _0898_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_0_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_99_clk clkbuf_4_4_0_clk/X VGND VPWR _1726_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_0_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_368 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_210 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_468 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_23_clk clkbuf_4_8_0_clk/X VGND VPWR _0761_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_7_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_62 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0530_ _1182_/CLK _0530_/D VGND VPWR _0531_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0461_ _1182_/CLK _0461_/D VGND VPWR _0463_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0392_ _1104_/CLK _0392_/D VGND VPWR _0393_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_66_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_262 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1013_ _1017_/CLK _1013_/D VGND VPWR _1014_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_14_clk clkbuf_4_9_0_clk/X VGND VPWR _0169_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1915_ _1918_/CLK _1915_/D VGND VPWR _1916_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_8_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1846_ _1846_/CLK _1846_/D VGND VPWR _1847_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1777_ _1783_/CLK _1777_/D VGND VPWR _1779_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0728_ _0793_/CLK _0728_/D VGND VPWR _0729_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0659_ _0916_/CLK _0659_/D VGND VPWR _0661_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_8_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_8_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_40_235 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_453 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1700_ _1710_/CLK _1700_/D VGND VPWR _1701_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1631_ _1673_/CLK _1631_/D VGND VPWR _1632_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1562_ _1594_/CLK _1562_/D VGND VPWR _1563_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1493_ _1600_/CLK _1493_/D VGND VPWR _1494_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0513_ _0529_/CLK _0513_/D VGND VPWR _0514_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_3_clk clkbuf_4_2_0_clk/X VGND VPWR _1302_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0444_ _0973_/CLK _0444_/D VGND VPWR _0445_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0375_ _1103_/CLK _0375_/D VGND VPWR _0376_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_496 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_246 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_566 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1829_ _1846_/CLK _1829_/D VGND VPWR _1830_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_508 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0160_ _1170_/CLK _0160_/D VGND VPWR _0161_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_76_496 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0091_ _1229_/CLK _0091_/D VGND VPWR _0092_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0993_ _1010_/CLK _0993_/D VGND VPWR _0994_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_74_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1614_ _1833_/CLK _1614_/D VGND VPWR _1615_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_50 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1545_ _1936_/CLK _1545_/D VGND VPWR _1546_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1476_ _1726_/CLK _1476_/D VGND VPWR _1477_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0427_ _0966_/CLK _0427_/D VGND VPWR _0428_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0358_ _1112_/CLK _0358_/D VGND VPWR _0359_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0289_ _0295_/CLK _0289_/D VGND VPWR _0290_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_330 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_89 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_70 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1330_ _1336_/CLK _1330_/D VGND VPWR _1331_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1261_ _1320_/CLK _1261_/D VGND VPWR _1262_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0212_ _0214_/CLK _0212_/D VGND VPWR _0213_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1192_ _1816_/CLK _1192_/D VGND VPWR _1193_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0143_ _1635_/CLK _0143_/D VGND VPWR _0154_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0074_ _1816_/CLK _0074_/D VGND VPWR _0075_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0976_ _0977_/CLK _0976_/D VGND VPWR _0977_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1528_ _1587_/CLK _1528_/D VGND VPWR _1529_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1459_ _1695_/CLK _1459_/D VGND VPWR _1460_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_27_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_91 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0830_ _0845_/CLK _0830_/D VGND VPWR _0831_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0761_ _0761_/CLK _0761_/D VGND VPWR _0762_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0692_ _0906_/CLK _0692_/D VGND VPWR _0694_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1313_ _1320_/CLK _1313_/D VGND VPWR _1314_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_506 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1244_ _1244_/CLK _1244_/D VGND VPWR _1245_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_422 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1175_ _1180_/CLK _1175_/D VGND VPWR _1176_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0126_ _1138_/CLK _0126_/D VGND VPWR _0127_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0057_ _1185_/CLK _0057_/D VGND VPWR _0058_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0959_ _0966_/CLK _0959_/D VGND VPWR _0960_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_550 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_620 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1931_ _1956_/CLK _1931_/D VGND VPWR _1933_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1862_ _1862_/CLK _1862_/D VGND VPWR _1863_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0813_ _0813_/CLK _0813_/D VGND VPWR _0815_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1793_ _1794_/CLK _1793_/D VGND VPWR _1794_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0744_ _0761_/CLK _0744_/D VGND VPWR _0745_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0675_ _0874_/CLK _0675_/D VGND VPWR _0676_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1227_ _1229_/CLK _1227_/D VGND VPWR _1228_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1158_ _1162_/CLK _1158_/D VGND VPWR _1159_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0109_ _0743_/CLK _0109_/D VGND VPWR _0111_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1089_ _1841_/CLK _1089_/D VGND VPWR _1100_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_285 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_266 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_145 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0460_ _0585_/CLK _0460_/D VGND VPWR _0461_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_439 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0391_ _1103_/CLK _0391_/D VGND VPWR _0392_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1012_ _1686_/CLK _1012_/D VGND VPWR _1023_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1914_ _1918_/CLK _1914_/D VGND VPWR _1915_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_494 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1845_ _1862_/CLK _1845_/D VGND VPWR _1846_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1776_ _1783_/CLK _1776_/D VGND VPWR _1777_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0727_ _0761_/CLK _0727_/D VGND VPWR _0728_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0658_ _0916_/CLK _0658_/D VGND VPWR _0659_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0589_ _0973_/CLK _0589_/D VGND VPWR _0590_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_494 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_247 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_244 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1630_ _1659_/CLK _1630_/D VGND VPWR _1631_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1561_ _1594_/CLK _1561_/D VGND VPWR _1562_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1492_ _1600_/CLK _1492_/D VGND VPWR _1493_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0512_ _0529_/CLK _0512_/D VGND VPWR _0513_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0443_ _0973_/CLK _0443_/D VGND VPWR _0444_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0374_ _1907_/CLK _0374_/D VGND VPWR _0385_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_50_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_383 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_578 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1828_ _1846_/CLK _1828_/D VGND VPWR _1829_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1759_ _1772_/CLK _1759_/D VGND VPWR _1760_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_214 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0090_ _1229_/CLK _0090_/D VGND VPWR _0091_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0992_ _1017_/CLK _0992_/D VGND VPWR _0993_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1613_ _1833_/CLK _1613_/D VGND VPWR _1614_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1544_ _1936_/CLK _1544_/D VGND VPWR _1545_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1475_ _1726_/CLK _1475_/D VGND VPWR _1476_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_7_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_7_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_0426_ _0953_/CLK _0426_/D VGND VPWR _0427_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0357_ _1180_/CLK _0357_/D VGND VPWR _0358_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0288_ _0295_/CLK _0288_/D VGND VPWR _0289_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_239 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_11 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1260_ _1302_/CLK _1260_/D VGND VPWR _1261_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0211_ _0316_/CLK _0211_/D VGND VPWR _0212_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1191_ _1816_/CLK _1191_/D VGND VPWR _1192_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_76_283 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0142_ _1162_/CLK _0142_/D VGND VPWR _0144_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_456 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0073_ _1228_/CLK _0073_/D VGND VPWR _0074_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0975_ _0977_/CLK _0975_/D VGND VPWR _0976_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_10_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1527_ _1578_/CLK _1527_/D VGND VPWR _1528_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1458_ _1710_/CLK _1458_/D VGND VPWR _1459_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0409_ _0622_/CLK _0409_/D VGND VPWR _0410_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1389_ _1764_/CLK _1389_/D VGND VPWR _1390_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_92 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0760_ _0791_/CLK _0760_/D VGND VPWR _0761_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0691_ _0906_/CLK _0691_/D VGND VPWR _0692_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1312_ _1808_/CLK _1312_/D VGND VPWR _1313_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1243_ _1244_/CLK _1243_/D VGND VPWR _1244_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_2_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1174_ _1180_/CLK _1174_/D VGND VPWR _1175_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_117 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0125_ _1138_/CLK _0125_/D VGND VPWR _0126_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0056_ _1185_/CLK _0056_/D VGND VPWR _0057_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0958_ _0966_/CLK _0958_/D VGND VPWR _0959_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0889_ _0894_/CLK _0889_/D VGND VPWR _0890_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_327 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_367 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1930_ _1956_/CLK _1930_/D VGND VPWR _1931_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1861_ _1997_/CLK _1861_/D VGND VPWR _1862_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0812_ _0813_/CLK _0812_/D VGND VPWR _0813_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1792_ _1794_/CLK _1792_/D VGND VPWR _1793_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0743_ _0743_/CLK _0743_/D VGND VPWR _0744_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0674_ _0898_/CLK _0674_/D VGND VPWR _0675_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1226_ _1226_/CLK _1226_/D VGND VPWR _1227_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_415 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1157_ _1162_/CLK _1157_/D VGND VPWR _1158_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0108_ _0743_/CLK _0108_/D VGND VPWR _0109_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1088_ _1088_/CLK _1088_/D VGND VPWR _1090_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0039_ _0169_/CLK _0039_/D VGND VPWR _0040_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_231 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_100_clk clkbuf_4_4_0_clk/X VGND VPWR _1687_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0390_ _1104_/CLK _0390_/D VGND VPWR _0391_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1011_ _1017_/CLK _1011_/D VGND VPWR _1013_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_47_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1913_ _1918_/CLK _1913_/D VGND VPWR _1914_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1844_ _1987_/CLK _1844_/D VGND VPWR _1855_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1775_ _1788_/CLK _1775_/D VGND VPWR _1776_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0726_ _1665_/CLK _0726_/D VGND VPWR _0737_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0657_ _0916_/CLK _0657_/D VGND VPWR _0658_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0588_ _0595_/CLK _0588_/D VGND VPWR _0589_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1209_ _1320_/CLK _1209_/D VGND VPWR _1210_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_212 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_215 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1560_ _1594_/CLK _1560_/D VGND VPWR _1561_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0511_ _0529_/CLK _0511_/D VGND VPWR _0512_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1491_ _1965_/CLK _1491_/D VGND VPWR _1492_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0442_ _0973_/CLK _0442_/D VGND VPWR _0443_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0373_ _1103_/CLK _0373_/D VGND VPWR _0375_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_226 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1827_ _1827_/CLK _1827_/D VGND VPWR _1828_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1758_ _1772_/CLK _1758_/D VGND VPWR _1759_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1689_ _1695_/CLK _1689_/D VGND VPWR _1690_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0709_ _1127_/CLK _0709_/D VGND VPWR _0710_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_414 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0991_ _1017_/CLK _0991_/D VGND VPWR _0992_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1612_ _1833_/CLK _1612_/D VGND VPWR _1613_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_30 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1543_ _1918_/CLK _1543_/D VGND VPWR _1544_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1474_ _1726_/CLK _1474_/D VGND VPWR _1475_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0425_ _0953_/CLK _0425_/D VGND VPWR _0426_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0356_ _1088_/CLK _0356_/D VGND VPWR _0357_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_145 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0287_ _0295_/CLK _0287_/D VGND VPWR _0288_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_115 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_80_clk clkbuf_4_7_0_clk/X VGND VPWR _0539_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_96_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0210_ _0214_/CLK _0210_/D VGND VPWR _0211_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1190_ _1816_/CLK _1190_/D VGND VPWR _1191_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0141_ _1170_/CLK _0141_/D VGND VPWR _0142_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_91_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_468 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0072_ _1816_/CLK _0072_/D VGND VPWR _0073_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_71_clk clkbuf_4_13_0_clk/X VGND VPWR _1033_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_51_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0974_ _0977_/CLK _0974_/D VGND VPWR _0975_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1526_ _1587_/CLK _1526_/D VGND VPWR _1527_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1457_ _1687_/CLK _1457_/D VGND VPWR _1458_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1388_ _1764_/CLK _1388_/D VGND VPWR _1389_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0408_ _0622_/CLK _0408_/D VGND VPWR _0409_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0339_ _1181_/CLK _0339_/D VGND VPWR _0340_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_70_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_62_clk clkbuf_4_15_0_clk/X VGND VPWR _0998_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_104_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_53_clk clkbuf_4_14_0_clk/X VGND VPWR _0632_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_61_438 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_6_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_6_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_0690_ _0906_/CLK _0690_/D VGND VPWR _0691_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1311_ _1320_/CLK _1311_/D VGND VPWR _1312_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1242_ _1244_/CLK _1242_/D VGND VPWR _1243_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_2_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1173_ _1180_/CLK _1173_/D VGND VPWR _1174_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0124_ _1138_/CLK _0124_/D VGND VPWR _0125_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0055_ _1635_/CLK _0055_/D VGND VPWR _0066_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_44_clk clkbuf_4_9_0_clk/X VGND VPWR _1180_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0957_ _1826_/CLK _0957_/D VGND VPWR _0968_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0888_ _0894_/CLK _0888_/D VGND VPWR _0889_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1509_ _1604_/CLK _1509_/D VGND VPWR _1510_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_46_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_35_clk clkbuf_4_11_0_clk/X VGND VPWR _0916_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_11_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_33 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_26_clk clkbuf_4_10_0_clk/X VGND VPWR _0813_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_14_184 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1860_ _1997_/CLK _1860_/D VGND VPWR _1861_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_42_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1791_ _1794_/CLK _1791_/D VGND VPWR _1792_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0811_ _0813_/CLK _0811_/D VGND VPWR _0812_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0742_ _0743_/CLK _0742_/D VGND VPWR _0743_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0673_ _0874_/CLK _0673_/D VGND VPWR _0674_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_42_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1225_ _1226_/CLK _1225_/D VGND VPWR _1226_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1156_ _1163_/CLK _1156_/D VGND VPWR _1157_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_16_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0107_ _0743_/CLK _0107_/D VGND VPWR _0108_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1087_ _1088_/CLK _1087_/D VGND VPWR _1088_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_17_clk clkbuf_4_9_0_clk/X VGND VPWR _1163_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0038_ _0169_/CLK _0038_/D VGND VPWR _0039_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1989_ _1995_/CLK _1989_/D VGND VPWR _1990_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_4_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_327 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1010_ _1010_/CLK _1010_/D VGND VPWR _1011_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1912_ _1918_/CLK _1912_/D VGND VPWR _1913_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_8_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1843_ _1846_/CLK _1843_/D VGND VPWR _1845_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1774_ _1788_/CLK _1774_/D VGND VPWR _1775_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0725_ _0793_/CLK _0725_/D VGND VPWR _0727_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0656_ _0916_/CLK _0656_/D VGND VPWR _0657_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_6_clk clkbuf_4_2_0_clk/X VGND VPWR _1226_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0587_ _0595_/CLK _0587_/D VGND VPWR _0588_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1208_ _1233_/CLK _1208_/D VGND VPWR _1209_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1139_ _1147_/CLK _1139_/D VGND VPWR _1140_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_43_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_382 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0510_ _0529_/CLK _0510_/D VGND VPWR _0511_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1490_ _1600_/CLK _1490_/D VGND VPWR _1491_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0441_ _0973_/CLK _0441_/D VGND VPWR _0442_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0372_ _1103_/CLK _0372_/D VGND VPWR _0373_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_382 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1826_ _1826_/CLK _1826_/D VGND VPWR _1827_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1757_ _1772_/CLK _1757_/D VGND VPWR _1758_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1688_ _1695_/CLK _1688_/D VGND VPWR _1689_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0708_ _1127_/CLK _0708_/D VGND VPWR _0709_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0639_ _0919_/CLK _0639_/D VGND VPWR _0640_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_124 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_414 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0990_ _1686_/CLK _0990_/D VGND VPWR _1001_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1611_ _1611_/CLK _1611_/D VGND VPWR _1612_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1542_ _1918_/CLK _1542_/D VGND VPWR _1543_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1473_ _1726_/CLK _1473_/D VGND VPWR _1474_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0424_ _0953_/CLK _0424_/D VGND VPWR _0425_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0355_ _1088_/CLK _0355_/D VGND VPWR _0356_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0286_ _0539_/CLK _0286_/D VGND VPWR _0297_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1809_ _1814_/CLK _1809_/D VGND VPWR _1810_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_466 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_425 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_341 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_201 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0140_ _1170_/CLK _0140_/D VGND VPWR _0141_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0071_ _1816_/CLK _0071_/D VGND VPWR _0072_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0973_ _0973_/CLK _0973_/D VGND VPWR _0974_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_72_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1525_ _1587_/CLK _1525_/D VGND VPWR _1526_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1456_ _1710_/CLK _1456_/D VGND VPWR _1457_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1387_ _1764_/CLK _1387_/D VGND VPWR _1388_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_252 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0407_ _1907_/CLK _0407_/D VGND VPWR _0418_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_27_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0338_ _1070_/CLK _0338_/D VGND VPWR _0339_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0269_ _0280_/CLK _0269_/D VGND VPWR _0270_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_50 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_94 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1310_ _1320_/CLK _1310_/D VGND VPWR _1311_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1241_ _1244_/CLK _1241_/D VGND VPWR _1242_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_2_54 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1172_ _1180_/CLK _1172_/D VGND VPWR _1173_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0123_ _1138_/CLK _0123_/D VGND VPWR _0124_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0054_ _0169_/CLK _0054_/D VGND VPWR _0056_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0956_ _0966_/CLK _0956_/D VGND VPWR _0958_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0887_ _0916_/CLK _0887_/D VGND VPWR _0888_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1508_ _1611_/CLK _1508_/D VGND VPWR _1509_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1439_ _1686_/CLK _1439_/D VGND VPWR _1440_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_546 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_436 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1790_ _1794_/CLK _1790_/D VGND VPWR _1791_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0810_ _0831_/CLK _0810_/D VGND VPWR _0811_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0741_ _0743_/CLK _0741_/D VGND VPWR _0742_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0672_ _0874_/CLK _0672_/D VGND VPWR _0673_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_35_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1224_ _1226_/CLK _1224_/D VGND VPWR _1225_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1155_ _1185_/CLK _1155_/D VGND VPWR _1166_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1086_ _1088_/CLK _1086_/D VGND VPWR _1087_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0106_ _0743_/CLK _0106_/D VGND VPWR _0107_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0037_ _0169_/CLK _0037_/D VGND VPWR _0038_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1988_ _1991_/CLK _1988_/D VGND VPWR _1989_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0939_ _1077_/CLK _0939_/D VGND VPWR _0940_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_5_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_5_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_102_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_542 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1911_ _1918_/CLK _1911_/D VGND VPWR _1912_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_464 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1842_ _1862_/CLK _1842_/D VGND VPWR _1843_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1773_ _1788_/CLK _1773_/D VGND VPWR _1774_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0724_ _0791_/CLK _0724_/D VGND VPWR _0725_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0655_ _0916_/CLK _0655_/D VGND VPWR _0656_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0586_ _0595_/CLK _0586_/D VGND VPWR _0587_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_57_328 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1207_ _1233_/CLK _1207_/D VGND VPWR _1208_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1138_ _1138_/CLK _1138_/D VGND VPWR _1139_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1069_ _1071_/CLK _1069_/D VGND VPWR _1070_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_230 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0440_ _0539_/CLK _0440_/D VGND VPWR _0451_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0371_ _1112_/CLK _0371_/D VGND VPWR _0372_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1825_ _1826_/CLK _1825_/D VGND VPWR _1826_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1756_ _1833_/CLK input1/X VGND VPWR _1767_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0707_ _0813_/CLK _0707_/D VGND VPWR _0708_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1687_ _1687_/CLK _1687_/D VGND VPWR _1688_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0638_ _1649_/CLK _0638_/D VGND VPWR _0649_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0569_ _0595_/CLK _0569_/D VGND VPWR _0570_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_57_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_438 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_72 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1610_ _1987_/CLK _1610_/D VGND VPWR _1611_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1541_ _1578_/CLK _1541_/D VGND VPWR _1542_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1472_ _1726_/CLK _1472_/D VGND VPWR _1473_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0423_ _0622_/CLK _0423_/D VGND VPWR _0424_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0354_ _1112_/CLK _0354_/D VGND VPWR _0355_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_286 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0285_ _1033_/CLK _0285_/D VGND VPWR _0287_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1808_ _1808_/CLK _1808_/D VGND VPWR _1809_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1739_ _1747_/CLK _1739_/D VGND VPWR _1740_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_618 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0070_ _1816_/CLK _0070_/D VGND VPWR _0071_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0972_ _0977_/CLK _0972_/D VGND VPWR _0973_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1524_ _1587_/CLK _1524_/D VGND VPWR _1525_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1455_ _1710_/CLK _1455_/D VGND VPWR _1456_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1386_ _1764_/CLK _1386_/D VGND VPWR _1387_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0406_ _0622_/CLK _0406_/D VGND VPWR _0408_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0337_ _1070_/CLK _0337_/D VGND VPWR _0338_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_264 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0268_ _0280_/CLK _0268_/D VGND VPWR _0269_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0199_ _1178_/CLK _0199_/D VGND VPWR _0200_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_201 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_621 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_95 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1240_ _1244_/CLK _1240_/D VGND VPWR _1241_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_2_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1171_ _1180_/CLK _1171_/D VGND VPWR _1172_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0122_ _1138_/CLK _0122_/D VGND VPWR _0123_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0053_ _1841_/CLK _0053_/D VGND VPWR _0054_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0955_ _0966_/CLK _0955_/D VGND VPWR _0956_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_121_clk clkbuf_4_0_0_clk/X VGND VPWR _1364_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_9_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0886_ _0916_/CLK _0886_/D VGND VPWR _0887_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1507_ _1604_/CLK _1507_/D VGND VPWR _1508_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_103 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1438_ _1814_/CLK _1438_/D VGND VPWR _1439_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1369_ _1373_/CLK _1369_/D VGND VPWR _1370_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_112_clk clkbuf_4_1_0_clk/X VGND VPWR _1710_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_78_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0740_ _1138_/CLK _0740_/D VGND VPWR _0741_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_103_clk clkbuf_4_6_0_clk/X VGND VPWR _1665_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_10_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0671_ _1665_/CLK _0671_/D VGND VPWR _0682_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1223_ _1228_/CLK _1223_/D VGND VPWR _1224_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_201 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1154_ _1163_/CLK _1154_/D VGND VPWR _1156_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1085_ _1088_/CLK _1085_/D VGND VPWR _1086_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0105_ _0750_/CLK _0105_/D VGND VPWR _0106_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0036_ _1846_/CLK _0036_/D VGND VPWR _0037_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1987_ _1987_/CLK _1987_/D VGND VPWR _1987_/Q VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0938_ _1077_/CLK _0938_/D VGND VPWR _0939_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0869_ _1665_/CLK _0869_/D VGND VPWR _0880_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_565 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_554 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1910_ _1987_/CLK _1910_/D VGND VPWR _1921_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1841_ _1841_/CLK _1841_/D VGND VPWR _1842_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1772_ _1772_/CLK _1772_/D VGND VPWR _1773_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0723_ _0791_/CLK _0723_/D VGND VPWR _0724_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0654_ _0916_/CLK _0654_/D VGND VPWR _0655_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0585_ _0585_/CLK _0585_/D VGND VPWR _0586_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1206_ _1233_/CLK _1206_/D VGND VPWR _1207_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1137_ _1147_/CLK _1137_/D VGND VPWR _1138_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1068_ _1071_/CLK _1068_/D VGND VPWR _1069_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0019_ _1858_/CLK _0019_/D VGND VPWR _0020_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_270 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_242 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_351 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_210 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0370_ _1112_/CLK _0370_/D VGND VPWR _0371_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_4_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_4_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_1824_ _1846_/CLK _1824_/D VGND VPWR _1825_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1755_ _1783_/CLK _1755_/D VGND VPWR _1757_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_7_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0706_ _1127_/CLK _0706_/D VGND VPWR _0707_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1686_ _1686_/CLK _1686_/D VGND VPWR _1687_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0637_ _0642_/CLK _0637_/D VGND VPWR _0639_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0568_ _0595_/CLK _0568_/D VGND VPWR _0569_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0499_ _0508_/CLK _0499_/D VGND VPWR _0500_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_57_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_92_clk clkbuf_4_5_0_clk/X VGND VPWR _1604_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_53_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_240 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_83_clk clkbuf_4_7_0_clk/X VGND VPWR _1975_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_32_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_11 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1540_ _1578_/CLK _1540_/D VGND VPWR _1541_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1471_ _1673_/CLK _1471_/D VGND VPWR _1472_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0422_ _0953_/CLK _0422_/D VGND VPWR _0423_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0353_ _1088_/CLK _0353_/D VGND VPWR _0354_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_10_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0284_ _1980_/CLK _0284_/D VGND VPWR _0285_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_298 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_74_clk clkbuf_4_12_0_clk/X VGND VPWR _1996_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_35_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1807_ _1814_/CLK _1807_/D VGND VPWR _1808_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1738_ _1747_/CLK _1738_/D VGND VPWR _1739_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1669_ _1673_/CLK _1669_/D VGND VPWR _1670_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_65_clk clkbuf_4_13_0_clk/X VGND VPWR _1017_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_73_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_435 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_56_clk clkbuf_4_14_0_clk/X VGND VPWR _0973_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_55_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0971_ _1039_/CLK _0971_/D VGND VPWR _0972_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1523_ _1587_/CLK _1523_/D VGND VPWR _1524_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1454_ _1695_/CLK _1454_/D VGND VPWR _1455_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0405_ _0622_/CLK _0405_/D VGND VPWR _0406_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1385_ _1764_/CLK _1385_/D VGND VPWR _1386_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0336_ _1070_/CLK _0336_/D VGND VPWR _0337_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_298 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0267_ _0280_/CLK _0267_/D VGND VPWR _0268_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_47_clk clkbuf_4_12_0_clk/X VGND VPWR _1071_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0198_ _1594_/CLK _0198_/D VGND VPWR _0209_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_118 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_38_clk clkbuf_4_11_0_clk/X VGND VPWR _0932_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XPHY_30 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_567 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1170_ _1170_/CLK _1170_/D VGND VPWR _1171_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_2_78 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0121_ _1635_/CLK _0121_/D VGND VPWR _0132_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_70 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_29_clk clkbuf_4_10_0_clk/X VGND VPWR _0864_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0052_ _1185_/CLK _0052_/D VGND VPWR _0053_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0954_ _0966_/CLK _0954_/D VGND VPWR _0955_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0885_ _0894_/CLK _0885_/D VGND VPWR _0886_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_143 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1506_ _1604_/CLK _1506_/D VGND VPWR _1507_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1437_ _1814_/CLK _1437_/D VGND VPWR _1438_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1368_ _1373_/CLK _1368_/D VGND VPWR _1369_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_28_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0319_ _0539_/CLK _0319_/D VGND VPWR _0330_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1299_ _1302_/CLK _1299_/D VGND VPWR _1300_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0670_ _0874_/CLK _0670_/D VGND VPWR _0672_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_397 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1222_ _1229_/CLK _1222_/D VGND VPWR _1223_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_77_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1153_ _1163_/CLK _1153_/D VGND VPWR _1154_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1084_ _1088_/CLK _1084_/D VGND VPWR _1085_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0104_ _0750_/CLK _0104_/D VGND VPWR _0105_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0035_ _1858_/CLK _0035_/D VGND VPWR _0036_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1986_ _1991_/CLK _1986_/D VGND VPWR _1988_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0937_ _0953_/CLK _0937_/D VGND VPWR _0938_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_9_clk clkbuf_4_2_0_clk/X VGND VPWR _1233_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0868_ _0874_/CLK _0868_/D VGND VPWR _0870_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0799_ _0813_/CLK _0799_/D VGND VPWR _0800_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_102 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_102 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1840_ _1846_/CLK _1840_/D VGND VPWR _1841_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1771_ _1772_/CLK _1771_/D VGND VPWR _1772_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0722_ _0791_/CLK _0722_/D VGND VPWR _0723_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0653_ _0916_/CLK _0653_/D VGND VPWR _0654_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0584_ _0973_/CLK _0584_/D VGND VPWR _0585_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_40_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_606 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1205_ _1808_/CLK _1205_/D VGND VPWR _1206_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1136_ _1138_/CLK _1136_/D VGND VPWR _1137_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1067_ _1826_/CLK _1067_/D VGND VPWR _1078_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0018_ _1858_/CLK _0018_/D VGND VPWR _0019_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1969_ _1973_/CLK _1969_/D VGND VPWR _1970_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_555 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_311 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_211 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_415 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_466 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1823_ _1826_/CLK _1823_/D VGND VPWR _1824_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1754_ _1754_/CLK _1754_/D VGND VPWR _1755_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0705_ _0813_/CLK _0705_/D VGND VPWR _0706_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1685_ _1686_/CLK _1685_/D VGND VPWR _1686_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_508 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0636_ _0642_/CLK _0636_/D VGND VPWR _0637_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0567_ _0595_/CLK _0567_/D VGND VPWR _0568_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_57_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0498_ _0508_/CLK _0498_/D VGND VPWR _0499_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1119_ _1163_/CLK _1119_/D VGND VPWR _1120_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_196 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1470_ _1726_/CLK _1470_/D VGND VPWR _1471_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0421_ _0953_/CLK _0421_/D VGND VPWR _0422_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0352_ _1907_/CLK _0352_/D VGND VPWR _0363_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0283_ _1033_/CLK _0283_/D VGND VPWR _0284_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_90_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1806_ _1808_/CLK _1806_/D VGND VPWR _1807_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1737_ _1747_/CLK _1737_/D VGND VPWR _1738_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1668_ _1687_/CLK _1668_/D VGND VPWR _1669_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0619_ _0632_/CLK _0619_/D VGND VPWR _0620_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1599_ _1600_/CLK _1599_/D VGND VPWR _1600_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_3_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_3_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_13_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0970_ _1046_/CLK _0970_/D VGND VPWR _0971_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_32_358 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1522_ _1587_/CLK _1522_/D VGND VPWR _1523_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1453_ _1695_/CLK _1453_/D VGND VPWR _1454_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0404_ _0642_/CLK _0404_/D VGND VPWR _0405_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1384_ _1764_/CLK _1384_/D VGND VPWR _1385_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_542 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0335_ _1070_/CLK _0335_/D VGND VPWR _0336_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0266_ _0280_/CLK _0266_/D VGND VPWR _0267_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0197_ _1178_/CLK _0197_/D VGND VPWR _0199_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_50_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_20 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_20 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_579 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0120_ _1138_/CLK _0120_/D VGND VPWR _0122_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0051_ _0169_/CLK _0051_/D VGND VPWR _0052_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_166 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0953_ _0953_/CLK _0953_/D VGND VPWR _0954_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0884_ _0894_/CLK _0884_/D VGND VPWR _0885_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_70_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1505_ _1604_/CLK _1505_/D VGND VPWR _1506_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_590 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1436_ _1814_/CLK _1436_/D VGND VPWR _1437_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1367_ _1373_/CLK _1367_/D VGND VPWR _1368_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0318_ _1055_/CLK _0318_/D VGND VPWR _0320_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1298_ _1302_/CLK _1298_/D VGND VPWR _1299_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0249_ _1980_/CLK _0249_/D VGND VPWR _0250_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_499 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_394 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_291 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_571 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1221_ _1816_/CLK _1221_/D VGND VPWR _1222_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1152_ _1163_/CLK _1152_/D VGND VPWR _1153_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1083_ _1181_/CLK _1083_/D VGND VPWR _1084_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0103_ _1226_/CLK _0103_/D VGND VPWR _0104_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_228 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0034_ _1846_/CLK _0034_/D VGND VPWR _0035_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1985_ _1985_/CLK _1985_/D VGND VPWR _1986_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0936_ _1077_/CLK _0936_/D VGND VPWR _0937_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0867_ _0874_/CLK _0867_/D VGND VPWR _0868_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0798_ _0813_/CLK _0798_/D VGND VPWR _0799_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1419_ _1783_/CLK _1419_/D VGND VPWR _1420_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_191 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1770_ _1788_/CLK _1770_/D VGND VPWR _1771_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0721_ _1127_/CLK _0721_/D VGND VPWR _0722_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0652_ _0919_/CLK _0652_/D VGND VPWR _0653_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0583_ _1649_/CLK _0583_/D VGND VPWR _0594_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_320 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1204_ _1808_/CLK _1204_/D VGND VPWR _1205_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1135_ _1147_/CLK _1135_/D VGND VPWR _1136_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1066_ _1071_/CLK _1066_/D VGND VPWR _1068_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0017_ _0214_/CLK _0017_/D VGND VPWR _0018_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1968_ _1975_/CLK _1968_/D VGND VPWR _1969_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1899_ _1987_/CLK _1899_/D VGND VPWR _1910_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0919_ _0919_/CLK _0919_/D VGND VPWR _0920_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_618 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_201 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_212 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_172 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1822_ _1987_/CLK _1822_/D VGND VPWR _1833_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1753_ _1772_/CLK _1753_/D VGND VPWR _1754_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1684_ _1686_/CLK _1684_/D VGND VPWR _1685_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0704_ _1665_/CLK _0704_/D VGND VPWR _0715_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0635_ _0642_/CLK _0635_/D VGND VPWR _0636_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0566_ _0595_/CLK _0566_/D VGND VPWR _0567_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0497_ _0508_/CLK _0497_/D VGND VPWR _0498_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1118_ _1163_/CLK _1118_/D VGND VPWR _1119_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1049_ _1055_/CLK _1049_/D VGND VPWR _1050_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0420_ _0953_/CLK _0420_/D VGND VPWR _0421_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0351_ _1088_/CLK _0351_/D VGND VPWR _0353_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_426 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0282_ _0295_/CLK _0282_/D VGND VPWR _0283_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_90_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_595 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1805_ _1808_/CLK _1805_/D VGND VPWR _1806_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1736_ _1736_/CLK _1736_/D VGND VPWR _1737_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1667_ _1687_/CLK _1667_/D VGND VPWR _1668_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1598_ _1600_/CLK _1598_/D VGND VPWR _1599_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0618_ _0632_/CLK _0618_/D VGND VPWR _0619_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0549_ _0573_/CLK _0549_/D VGND VPWR _0551_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_470 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_172 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1521_ _1587_/CLK _1521_/D VGND VPWR _1522_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1452_ _1695_/CLK _1452_/D VGND VPWR _1453_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0403_ _0622_/CLK _0403_/D VGND VPWR _0404_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1383_ _1764_/CLK _1383_/D VGND VPWR _1384_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_554 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0334_ _1070_/CLK _0334_/D VGND VPWR _0335_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0265_ _0280_/CLK _0265_/D VGND VPWR _0266_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_82_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0196_ _0214_/CLK _0196_/D VGND VPWR _0197_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1719_ _1833_/CLK _1719_/D VGND VPWR _1720_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_10 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_115_clk clkbuf_4_1_0_clk/X VGND VPWR _1754_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_41_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0050_ _1841_/CLK _0050_/D VGND VPWR _0051_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0952_ _0953_/CLK _0952_/D VGND VPWR _0953_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_106_clk clkbuf_4_3_0_clk/X VGND VPWR _1846_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0883_ _0894_/CLK _0883_/D VGND VPWR _0884_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1504_ _1604_/CLK _1504_/D VGND VPWR _1505_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1435_ _1814_/CLK _1435_/D VGND VPWR _1436_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1366_ _1373_/CLK _1366_/D VGND VPWR _1367_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_373 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0317_ _1055_/CLK _0317_/D VGND VPWR _0318_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1297_ _1348_/CLK _1297_/D VGND VPWR _1298_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_102_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0248_ _1980_/CLK _0248_/D VGND VPWR _0249_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_70_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0179_ _1178_/CLK _0179_/D VGND VPWR _0180_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_11_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_2_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_105_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_478 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_123 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_583 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1220_ _1228_/CLK _1220_/D VGND VPWR _1221_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_77_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1151_ _1163_/CLK _1151_/D VGND VPWR _1152_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0102_ _1226_/CLK _0102_/D VGND VPWR _0103_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1082_ _1181_/CLK _1082_/D VGND VPWR _1083_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0033_ _1635_/CLK _0033_/D VGND VPWR _0044_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_45_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1984_ _1991_/CLK _1984_/D VGND VPWR _1985_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0935_ _1826_/CLK _0935_/D VGND VPWR _0946_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0866_ _0874_/CLK _0866_/D VGND VPWR _0867_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_106_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0797_ _0813_/CLK _0797_/D VGND VPWR _0798_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1418_ _1783_/CLK _1418_/D VGND VPWR _1419_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1349_ _1373_/CLK _1349_/D VGND VPWR _1350_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_376 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_159 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_384 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_240 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_95 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0720_ _0793_/CLK _0720_/D VGND VPWR _0721_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_6_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0651_ _0919_/CLK _0651_/D VGND VPWR _0652_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0582_ _0595_/CLK _0582_/D VGND VPWR _0584_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_97_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1203_ _1808_/CLK _1203_/D VGND VPWR _1204_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1134_ _1147_/CLK _1134_/D VGND VPWR _1135_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1065_ _1071_/CLK _1065_/D VGND VPWR _1066_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_18_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0016_ _0214_/CLK _0016_/D VGND VPWR _0017_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1967_ _1973_/CLK _1967_/D VGND VPWR _1968_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0918_ _0919_/CLK _0918_/D VGND VPWR _0919_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1898_ _1985_/CLK _1898_/D VGND VPWR _1900_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0849_ _0874_/CLK _0849_/D VGND VPWR _0850_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_95_clk clkbuf_4_4_0_clk/X VGND VPWR _1635_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_71_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_202 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_446 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_295 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_86_clk clkbuf_4_7_0_clk/X VGND VPWR _1918_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_35_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1821_ _1826_/CLK _1821_/D VGND VPWR _1823_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_287 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1752_ _1783_/CLK _1752_/D VGND VPWR _1753_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_10_clk clkbuf_4_3_0_clk/X VGND VPWR _1808_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_7_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1683_ _1687_/CLK _1683_/D VGND VPWR _1684_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0703_ _0906_/CLK _0703_/D VGND VPWR _0705_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0634_ _0642_/CLK _0634_/D VGND VPWR _0635_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0565_ _0595_/CLK _0565_/D VGND VPWR _0566_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0496_ _0998_/CLK _0496_/D VGND VPWR _0497_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_77_clk clkbuf_4_6_0_clk/X VGND VPWR _1997_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_38_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1117_ _1127_/CLK _1117_/D VGND VPWR _1118_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_387 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1048_ _1055_/CLK _1048_/D VGND VPWR _1049_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_68_clk clkbuf_4_13_0_clk/X VGND VPWR _1973_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_17_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0350_ _1088_/CLK _0350_/D VGND VPWR _0351_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_438 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0281_ _1033_/CLK _0281_/D VGND VPWR _0282_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_59_clk clkbuf_4_15_0_clk/X VGND VPWR _1182_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_85_82 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_368 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1804_ _1814_/CLK _1804_/D VGND VPWR _1805_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1735_ _1736_/CLK _1735_/D VGND VPWR _1736_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1666_ _1673_/CLK _1666_/D VGND VPWR _1667_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1597_ _1600_/CLK _1597_/D VGND VPWR _1598_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0617_ _0632_/CLK _0617_/D VGND VPWR _0618_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0548_ _0573_/CLK _0548_/D VGND VPWR _0549_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0479_ _0998_/CLK _0479_/D VGND VPWR _0480_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_81_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_86 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_338 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1520_ _1587_/CLK _1520_/D VGND VPWR _1521_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1451_ _1695_/CLK _1451_/D VGND VPWR _1452_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1382_ _1764_/CLK _1382_/D VGND VPWR _1383_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0402_ _0642_/CLK _0402_/D VGND VPWR _0403_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0333_ _1070_/CLK _0333_/D VGND VPWR _0334_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0264_ _0539_/CLK _0264_/D VGND VPWR _0275_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_216 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0195_ _0214_/CLK _0195_/D VGND VPWR _0196_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1718_ _1833_/CLK _1718_/D VGND VPWR _1719_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1649_ _1649_/CLK _1649_/D VGND VPWR _1650_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_11 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_463 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_33 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_102 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_514 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_411 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0951_ _0966_/CLK _0951_/D VGND VPWR _0952_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_60_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_371 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0882_ _0894_/CLK _0882_/D VGND VPWR _0883_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1503_ _1604_/CLK _1503_/D VGND VPWR _1504_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1434_ _1814_/CLK _1434_/D VGND VPWR _1435_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1365_ _1373_/CLK _1365_/D VGND VPWR _1366_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0316_ _0316_/CLK _0316_/D VGND VPWR _0317_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1296_ _1348_/CLK _1296_/D VGND VPWR _1297_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0247_ _0295_/CLK _0247_/D VGND VPWR _0248_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0178_ _1180_/CLK _0178_/D VGND VPWR _0179_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_173 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_430 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_135 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_551 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1150_ _1163_/CLK _1150_/D VGND VPWR _1151_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0101_ _1226_/CLK _0101_/D VGND VPWR _0102_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1081_ _1104_/CLK _1081_/D VGND VPWR _1082_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0032_ _1846_/CLK _0032_/D VGND VPWR _0034_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_45_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1983_ _1991_/CLK _1983_/D VGND VPWR _1984_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0934_ _1077_/CLK _0934_/D VGND VPWR _0936_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0865_ _0874_/CLK _0865_/D VGND VPWR _0866_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0796_ _0813_/CLK _0796_/D VGND VPWR _0797_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1417_ _1783_/CLK _1417_/D VGND VPWR _1418_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1348_ _1348_/CLK _1348_/D VGND VPWR _1349_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1279_ _1348_/CLK _1279_/D VGND VPWR _1280_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_572 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0650_ _0916_/CLK _0650_/D VGND VPWR _0651_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0581_ _0585_/CLK _0581_/D VGND VPWR _0582_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1202_ _1233_/CLK _1202_/D VGND VPWR _1203_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_300 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_1_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_1_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_1133_ _1841_/CLK _1133_/D VGND VPWR _1144_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1064_ _1071_/CLK _1064_/D VGND VPWR _1065_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0015_ _1996_/CLK _0015_/D VGND VPWR _0016_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_33_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_436 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1966_ _1975_/CLK _1966_/D VGND VPWR _1967_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0917_ _0919_/CLK _0917_/D VGND VPWR _0918_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1897_ _1975_/CLK _1897_/D VGND VPWR _1898_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0848_ _0864_/CLK _0848_/D VGND VPWR _0849_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0779_ _0831_/CLK _0779_/D VGND VPWR _0780_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_203 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_369 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1820_ _1826_/CLK _1820_/D VGND VPWR _1821_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1751_ _1783_/CLK _1751_/D VGND VPWR _1752_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1682_ _1827_/CLK _1682_/D VGND VPWR _1683_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0702_ _0813_/CLK _0702_/D VGND VPWR _0703_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0633_ _0642_/CLK _0633_/D VGND VPWR _0634_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0564_ _0595_/CLK _0564_/D VGND VPWR _0565_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0495_ _0539_/CLK _0495_/D VGND VPWR _0506_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1116_ _1127_/CLK _1116_/D VGND VPWR _1117_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1047_ _1055_/CLK _1047_/D VGND VPWR _1048_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1949_ _1956_/CLK _1949_/D VGND VPWR _1950_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_494 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_76 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0280_ _0280_/CLK _0280_/D VGND VPWR _0281_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_75_494 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1803_ _1808_/CLK _1803_/D VGND VPWR _1804_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1734_ _1736_/CLK _1734_/D VGND VPWR _1735_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1665_ _1665_/CLK _1665_/D VGND VPWR _1666_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1596_ _1600_/CLK _1596_/D VGND VPWR _1597_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0616_ _1649_/CLK _0616_/D VGND VPWR _0627_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0547_ _0573_/CLK _0547_/D VGND VPWR _0548_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0478_ _0977_/CLK _0478_/D VGND VPWR _0479_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_177 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1450_ _1695_/CLK _1450_/D VGND VPWR _1451_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1381_ _1764_/CLK _1381_/D VGND VPWR _1382_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0401_ _0622_/CLK _0401_/D VGND VPWR _0402_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0332_ _1070_/CLK _0332_/D VGND VPWR _0333_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0263_ _1973_/CLK _0263_/D VGND VPWR _0265_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_228 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0194_ _0214_/CLK _0194_/D VGND VPWR _0195_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1717_ _1833_/CLK _1717_/D VGND VPWR _1718_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1648_ _1659_/CLK _1648_/D VGND VPWR _1649_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1579_ _1592_/CLK _1579_/D VGND VPWR _1580_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_23 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_250 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_89 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_78 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_383 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_526 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_559 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0950_ _0953_/CLK _0950_/D VGND VPWR _0951_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_13_383 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0881_ _0894_/CLK _0881_/D VGND VPWR _0882_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1502_ _1604_/CLK _1502_/D VGND VPWR _1503_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1433_ _1686_/CLK _1433_/D VGND VPWR _1434_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1364_ _1364_/CLK _1364_/D VGND VPWR _1365_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1295_ _1348_/CLK _1295_/D VGND VPWR _1296_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0315_ _1055_/CLK _0315_/D VGND VPWR _0316_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0246_ _1980_/CLK _0246_/D VGND VPWR _0247_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_55_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0177_ _1178_/CLK _0177_/D VGND VPWR _0178_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_434 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_442 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_103 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0100_ _1226_/CLK _0100_/D VGND VPWR _0101_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1080_ _1104_/CLK _1080_/D VGND VPWR _1081_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_389 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0031_ _1858_/CLK _0031_/D VGND VPWR _0032_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1982_ _1991_/CLK _1982_/D VGND VPWR _1983_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0933_ _1077_/CLK _0933_/D VGND VPWR _0934_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0864_ _0864_/CLK _0864_/D VGND VPWR _0865_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0795_ _0813_/CLK _0795_/D VGND VPWR _0796_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1416_ _1783_/CLK _1416_/D VGND VPWR _1417_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1347_ _1364_/CLK _1347_/D VGND VPWR _1348_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1278_ _1348_/CLK _1278_/D VGND VPWR _1279_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_356 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0229_ _1996_/CLK _0229_/D VGND VPWR _0230_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_327 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_364 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_592 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0580_ _0585_/CLK _0580_/D VGND VPWR _0581_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1201_ _1808_/CLK _1201_/D VGND VPWR _1202_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1132_ _1147_/CLK _1132_/D VGND VPWR _1134_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1063_ _1071_/CLK _1063_/D VGND VPWR _1064_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_92_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0014_ _1996_/CLK _0014_/D VGND VPWR _0015_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1965_ _1965_/CLK _1965_/D VGND VPWR _1976_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0916_ _0916_/CLK _0916_/D VGND VPWR _0917_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1896_ _1975_/CLK _1896_/D VGND VPWR _1897_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0847_ _1827_/CLK _0847_/D VGND VPWR _0858_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0778_ _0831_/CLK _0778_/D VGND VPWR _0779_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_88_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_204 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_359 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1750_ _1754_/CLK _1750_/D VGND VPWR _1751_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0701_ _0906_/CLK _0701_/D VGND VPWR _0702_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1681_ _1827_/CLK _1681_/D VGND VPWR _1682_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0632_ _0632_/CLK _0632_/D VGND VPWR _0633_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0563_ _0610_/CLK _0563_/D VGND VPWR _0564_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0494_ _0508_/CLK _0494_/D VGND VPWR _0496_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1115_ _1163_/CLK _1115_/D VGND VPWR _1116_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_80_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1046_ _1046_/CLK _1046_/D VGND VPWR _1047_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1948_ _1975_/CLK _1948_/D VGND VPWR _1949_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1879_ _1995_/CLK _1879_/D VGND VPWR _1880_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_624 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_551 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_0_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_0_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_4_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_602 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_142 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1802_ _1808_/CLK _1802_/D VGND VPWR _1803_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1733_ _1736_/CLK _1733_/D VGND VPWR _1734_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1664_ _1665_/CLK _1664_/D VGND VPWR _1665_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_104_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1595_ _1600_/CLK _1595_/D VGND VPWR _1596_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0615_ _0632_/CLK _0615_/D VGND VPWR _0617_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0546_ _0573_/CLK _0546_/D VGND VPWR _0547_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0477_ _0977_/CLK _0477_/D VGND VPWR _0478_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1029_ _1033_/CLK _1029_/D VGND VPWR _1030_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_41_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_118_clk clkbuf_4_0_0_clk/X VGND VPWR _1772_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_44_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1380_ _1764_/CLK _1380_/D VGND VPWR _1381_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0400_ _0642_/CLK _0400_/D VGND VPWR _0401_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0331_ _1070_/CLK _0331_/D VGND VPWR _0332_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_215 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0262_ _0280_/CLK _0262_/D VGND VPWR _0263_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_440 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0193_ _0214_/CLK _0193_/D VGND VPWR _0194_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_145 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_109_clk clkbuf_4_3_0_clk/X VGND VPWR _1814_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_16_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1716_ _1726_/CLK _1716_/D VGND VPWR _1717_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1647_ _1649_/CLK _1647_/D VGND VPWR _1648_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1578_ _1578_/CLK _1578_/D VGND VPWR _1579_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0529_ _0529_/CLK _0529_/D VGND VPWR _0530_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_443 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_513 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_156 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0880_ _1827_/CLK _0880_/D VGND VPWR _0891_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_40_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1501_ _1604_/CLK _1501_/D VGND VPWR _1502_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1432_ _1794_/CLK _1432_/D VGND VPWR _1433_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1363_ _1373_/CLK _1363_/D VGND VPWR _1364_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1294_ _1336_/CLK _1294_/D VGND VPWR _1295_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0314_ _0316_/CLK _0314_/D VGND VPWR _0315_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_538 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0245_ _1980_/CLK _0245_/D VGND VPWR _0246_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0176_ _1600_/CLK _0176_/D VGND VPWR _0187_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_593 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_159 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_546 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_410 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_107 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_218 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0030_ _1858_/CLK _0030_/D VGND VPWR _0031_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_60_298 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1981_ _1991_/CLK _1981_/D VGND VPWR _1982_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0932_ _0932_/CLK _0932_/D VGND VPWR _0933_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_40_clk clkbuf_4_11_0_clk/X VGND VPWR _1103_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0863_ _0864_/CLK _0863_/D VGND VPWR _0864_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0794_ _0813_/CLK _0794_/D VGND VPWR _0795_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1415_ _1783_/CLK _1415_/D VGND VPWR _1416_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1346_ _1364_/CLK _1346_/D VGND VPWR _1347_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1277_ _1348_/CLK _1277_/D VGND VPWR _1278_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0228_ _1996_/CLK _0228_/D VGND VPWR _0229_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0159_ _0169_/CLK _0159_/D VGND VPWR _0160_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_31_clk clkbuf_4_10_0_clk/X VGND VPWR _0894_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_98_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_201 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_98_clk clkbuf_4_4_0_clk/X VGND VPWR _1833_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_47_88 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_552 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_22_clk clkbuf_4_8_0_clk/X VGND VPWR _0750_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_6_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_405 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_89_clk clkbuf_4_5_0_clk/X VGND VPWR _1592_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1200_ _1808_/CLK _1200_/D VGND VPWR _1201_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1131_ _1147_/CLK _1131_/D VGND VPWR _1132_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1062_ _1071_/CLK _1062_/D VGND VPWR _1063_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0013_ _1996_/CLK _0013_/D VGND VPWR _0014_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_21_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1964_ _1973_/CLK _1964_/D VGND VPWR _1966_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_13_clk clkbuf_4_3_0_clk/X VGND VPWR _1841_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0915_ _0919_/CLK _0915_/D VGND VPWR _0916_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1895_ _1975_/CLK _1895_/D VGND VPWR _1896_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0846_ _0864_/CLK _0846_/D VGND VPWR _0848_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0777_ _0831_/CLK _0777_/D VGND VPWR _0778_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_471 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1329_ _1336_/CLK _1329_/D VGND VPWR _1330_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_17_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0700_ _1112_/CLK _0700_/D VGND VPWR _0701_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1680_ _1687_/CLK _1680_/D VGND VPWR _1681_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0631_ _0632_/CLK _0631_/D VGND VPWR _0632_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0562_ _0610_/CLK _0562_/D VGND VPWR _0563_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0493_ _0998_/CLK _0493_/D VGND VPWR _0494_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_2_clk clkbuf_4_2_0_clk/X VGND VPWR _1320_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_65_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_519 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1114_ _1163_/CLK _1114_/D VGND VPWR _1115_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_593 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_496 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1045_ _1826_/CLK _1045_/D VGND VPWR _1056_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1947_ _1975_/CLK _1947_/D VGND VPWR _1948_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1878_ _1985_/CLK _1878_/D VGND VPWR _1879_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0829_ _0831_/CLK _0829_/D VGND VPWR _0830_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_368 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_268 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1801_ _1814_/CLK _1801_/D VGND VPWR _1802_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1732_ _1736_/CLK _1732_/D VGND VPWR _1733_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1663_ _1665_/CLK _1663_/D VGND VPWR _1664_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0614_ _0632_/CLK _0614_/D VGND VPWR _0615_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1594_ _1594_/CLK _1594_/D VGND VPWR _1595_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0545_ _0573_/CLK _0545_/D VGND VPWR _0546_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0476_ _0977_/CLK _0476_/D VGND VPWR _0477_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_93_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1028_ _1033_/CLK _1028_/D VGND VPWR _1029_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_14_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_376 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_327 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_242 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0330_ _1907_/CLK _0330_/D VGND VPWR _0341_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0261_ _0280_/CLK _0261_/D VGND VPWR _0262_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0192_ _0214_/CLK _0192_/D VGND VPWR _0193_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_35_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1715_ _1726_/CLK _1715_/D VGND VPWR _1716_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1646_ _1649_/CLK _1646_/D VGND VPWR _1647_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1577_ _1578_/CLK _1577_/D VGND VPWR _1578_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0528_ _1649_/CLK _0528_/D VGND VPWR _0539_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_58_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0459_ _1182_/CLK _0459_/D VGND VPWR _0460_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_14 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_525 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_385 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1500_ _1604_/CLK _1500_/D VGND VPWR _1501_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1431_ _1794_/CLK _1431_/D VGND VPWR _1432_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1362_ _1364_/CLK _1362_/D VGND VPWR _1363_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1293_ _1336_/CLK _1293_/D VGND VPWR _1294_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0313_ _1055_/CLK _0313_/D VGND VPWR _0314_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0244_ _1980_/CLK _0244_/D VGND VPWR _0245_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0175_ _1178_/CLK _0175_/D VGND VPWR _0177_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_414 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1629_ _1673_/CLK _1629_/D VGND VPWR _1630_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_300 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_359 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_119 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_466 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1980_ _1980_/CLK _1980_/D VGND VPWR _1981_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_13_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0931_ _1077_/CLK _0931_/D VGND VPWR _0932_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0862_ _0874_/CLK _0862_/D VGND VPWR _0863_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0793_ _0793_/CLK _0793_/D VGND VPWR _0794_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_408 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1414_ _1747_/CLK _1414_/D VGND VPWR _1415_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1345_ _1772_/CLK _1345_/D VGND VPWR _1346_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1276_ _1348_/CLK _1276_/D VGND VPWR _1277_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_95_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0227_ _1996_/CLK _0227_/D VGND VPWR _0228_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0158_ _1170_/CLK _0158_/D VGND VPWR _0159_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_200 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0089_ _1229_/CLK _0089_/D VGND VPWR _0090_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_268 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_152 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1130_ _1147_/CLK _1130_/D VGND VPWR _1131_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1061_ _1071_/CLK _1061_/D VGND VPWR _1062_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_46_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0012_ _1996_/CLK _0012_/D VGND VPWR _0013_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_597 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1963_ _1973_/CLK _1963_/D VGND VPWR _1964_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0914_ _0919_/CLK _0914_/D VGND VPWR _0915_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1894_ _1975_/CLK _1894_/D VGND VPWR _1895_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0845_ _0845_/CLK _0845_/D VGND VPWR _0846_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0776_ _0831_/CLK _0776_/D VGND VPWR _0777_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1328_ _1336_/CLK _1328_/D VGND VPWR _1329_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1259_ _1302_/CLK _1259_/D VGND VPWR _1260_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_244 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_206 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_417 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_615 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_380 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0630_ _0632_/CLK _0630_/D VGND VPWR _0631_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0561_ _1649_/CLK _0561_/D VGND VPWR _0572_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0492_ _0508_/CLK _0492_/D VGND VPWR _0493_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1113_ _1163_/CLK _1113_/D VGND VPWR _1114_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_19_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1044_ _1046_/CLK _1044_/D VGND VPWR _1046_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_520 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1946_ _1956_/CLK _1946_/D VGND VPWR _1947_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1877_ _1987_/CLK _1877_/D VGND VPWR _1888_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0828_ _0831_/CLK _0828_/D VGND VPWR _0829_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0759_ _1665_/CLK _0759_/D VGND VPWR _0770_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_303 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1800_ _1833_/CLK _1800_/D VGND VPWR _1811_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1731_ _1736_/CLK _1731_/D VGND VPWR _1732_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1662_ _1665_/CLK _1662_/D VGND VPWR _1663_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0613_ _0632_/CLK _0613_/D VGND VPWR _0614_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1593_ _1600_/CLK _1593_/D VGND VPWR _1594_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0544_ _0573_/CLK _0544_/D VGND VPWR _0545_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0475_ _0998_/CLK _0475_/D VGND VPWR _0476_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1027_ _1033_/CLK _1027_/D VGND VPWR _1028_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1929_ _1956_/CLK _1929_/D VGND VPWR _1930_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_89_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_228 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_420 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0260_ _1973_/CLK _0260_/D VGND VPWR _0261_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0191_ _0214_/CLK _0191_/D VGND VPWR _0192_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_31_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_386 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1714_ _1726_/CLK _1714_/D VGND VPWR _1715_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1645_ _1649_/CLK _1645_/D VGND VPWR _1646_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1576_ _1592_/CLK _1576_/D VGND VPWR _1577_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0527_ _1182_/CLK _0527_/D VGND VPWR _0529_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_303 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0458_ _0585_/CLK _0458_/D VGND VPWR _0459_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0389_ _0932_/CLK _0389_/D VGND VPWR _0390_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_25 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_268 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_626 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_261 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_172 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1430_ _1794_/CLK _1430_/D VGND VPWR _1431_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1361_ _1364_/CLK _1361_/D VGND VPWR _1362_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0312_ _1046_/CLK _0312_/D VGND VPWR _0313_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1292_ _1336_/CLK _1292_/D VGND VPWR _1293_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0243_ _1980_/CLK _0243_/D VGND VPWR _0244_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_76_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0174_ _1180_/CLK _0174_/D VGND VPWR _0175_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_31_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1628_ _1673_/CLK _1628_/D VGND VPWR _1629_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1559_ _1907_/CLK _1559_/D VGND VPWR _1560_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_74_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_46 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_312 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_412 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_581 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_359 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_489 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_264 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0930_ _0932_/CLK _0930_/D VGND VPWR _0931_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_60_278 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0861_ _0864_/CLK _0861_/D VGND VPWR _0862_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_198 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0792_ _1827_/CLK _0792_/D VGND VPWR _0803_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1413_ _1783_/CLK _1413_/D VGND VPWR _1414_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1344_ _1772_/CLK _1344_/D VGND VPWR _1345_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1275_ _1348_/CLK _1275_/D VGND VPWR _1276_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_28_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_315 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0226_ _1996_/CLK _0226_/D VGND VPWR _0227_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0157_ _1170_/CLK _0157_/D VGND VPWR _0158_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0088_ _1635_/CLK _0088_/D VGND VPWR _0099_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_256 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_359 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_573 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_289 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_164 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_231 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1060_ _1071_/CLK _1060_/D VGND VPWR _1061_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0011_ _1965_/CLK _0011_/D VGND VPWR _0022_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_46_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1962_ _1973_/CLK _1962_/D VGND VPWR _1963_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0913_ _1826_/CLK _0913_/D VGND VPWR _0924_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1893_ _1991_/CLK _1893_/D VGND VPWR _1894_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0844_ _0864_/CLK _0844_/D VGND VPWR _0845_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0775_ _0831_/CLK _0775_/D VGND VPWR _0776_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_451 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1327_ _1336_/CLK _1327_/D VGND VPWR _1328_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1258_ _1302_/CLK _1258_/D VGND VPWR _1259_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0209_ _1594_/CLK _0209_/D VGND VPWR _0220_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1189_ _1816_/CLK _1189_/D VGND VPWR _1190_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_207 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_523 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_627 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0560_ _0610_/CLK _0560_/D VGND VPWR _0562_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0491_ _0998_/CLK _0491_/D VGND VPWR _0492_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_78_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1112_ _1112_/CLK _1112_/D VGND VPWR _1113_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_476 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1043_ _1046_/CLK _1043_/D VGND VPWR _1044_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1945_ _1975_/CLK _1945_/D VGND VPWR _1946_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1876_ _1995_/CLK _1876_/D VGND VPWR _1878_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0827_ _0831_/CLK _0827_/D VGND VPWR _0828_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0758_ _0761_/CLK _0758_/D VGND VPWR _0760_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_537 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0689_ _0898_/CLK _0689_/D VGND VPWR _0690_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_28_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_219 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_469 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_410 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_624 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_189 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_170 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1730_ _1736_/CLK _1730_/D VGND VPWR _1731_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1661_ _1665_/CLK _1661_/D VGND VPWR _1662_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0612_ _0632_/CLK _0612_/D VGND VPWR _0613_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1592_ _1592_/CLK _1592_/D VGND VPWR _1593_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0543_ _0573_/CLK _0543_/D VGND VPWR _0544_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0474_ _0998_/CLK _0474_/D VGND VPWR _0475_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_66_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_498 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1026_ _1033_/CLK _1026_/D VGND VPWR _1027_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1928_ _1956_/CLK _1928_/D VGND VPWR _1929_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1859_ _1997_/CLK _1859_/D VGND VPWR _1860_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_307 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_222 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_410 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0190_ _1178_/CLK _0190_/D VGND VPWR _0191_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_35_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_70_clk clkbuf_4_13_0_clk/X VGND VPWR _0295_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_31_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1713_ _1726_/CLK _1713_/D VGND VPWR _1714_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XANTENNA_0 _1181_/D VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
X_1644_ _1649_/CLK _1644_/D VGND VPWR _1645_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1575_ _1592_/CLK _1575_/D VGND VPWR _1576_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0526_ _1182_/CLK _0526_/D VGND VPWR _0527_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0457_ _0585_/CLK _0457_/D VGND VPWR _0458_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0388_ _1103_/CLK _0388_/D VGND VPWR _0389_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1009_ _1010_/CLK _1009_/D VGND VPWR _1010_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_61_clk clkbuf_4_15_0_clk/X VGND VPWR _0508_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_34_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_192 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_52_clk clkbuf_4_14_0_clk/X VGND VPWR _0622_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_82_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xoutput2 _1181_/D VGND VPWR out_window[0] VGND VPWR sky130_fd_sc_hd__clkbuf_2
X_1360_ _1364_/CLK _1360_/D VGND VPWR _1361_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0311_ _1046_/CLK _0311_/D VGND VPWR _0312_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1291_ _1336_/CLK _1291_/D VGND VPWR _1292_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0242_ _0539_/CLK _0242_/D VGND VPWR _0253_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_63_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0173_ _1180_/CLK _0173_/D VGND VPWR _0174_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_43_clk clkbuf_4_9_0_clk/X VGND VPWR _1181_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_51_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1627_ _1673_/CLK _1627_/D VGND VPWR _1628_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1558_ _1594_/CLK _1558_/D VGND VPWR _1559_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1489_ _1600_/CLK _1489_/D VGND VPWR _1490_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0509_ _0529_/CLK _0509_/D VGND VPWR _0510_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_265 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_34_clk clkbuf_4_11_0_clk/X VGND VPWR _0908_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_2_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_368 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_446 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_87 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_25_clk clkbuf_4_8_0_clk/X VGND VPWR _0793_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_41_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_144 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0860_ _0864_/CLK _0860_/D VGND VPWR _0861_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0791_ _0791_/CLK _0791_/D VGND VPWR _0793_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1412_ _1747_/CLK _1412_/D VGND VPWR _1413_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1343_ _1373_/CLK _1343_/D VGND VPWR _1344_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1274_ _1302_/CLK _1274_/D VGND VPWR _1275_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_327 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0225_ _1996_/CLK _0225_/D VGND VPWR _0226_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0156_ _1170_/CLK _0156_/D VGND VPWR _0157_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_91_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_16_clk clkbuf_4_9_0_clk/X VGND VPWR _1162_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0087_ _1229_/CLK _0087_/D VGND VPWR _0089_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0989_ _0998_/CLK _0989_/D VGND VPWR _0991_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_105_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_432 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_243 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0010_ _1997_/CLK _0010_/D VGND VPWR _0012_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_73_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1961_ _1973_/CLK _1961_/D VGND VPWR _1962_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_14_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0912_ _0916_/CLK _0912_/D VGND VPWR _0914_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1892_ _1991_/CLK _1892_/D VGND VPWR _1893_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0843_ _0864_/CLK _0843_/D VGND VPWR _0844_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0774_ _0845_/CLK _0774_/D VGND VPWR _0775_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_5_clk clkbuf_4_2_0_clk/X VGND VPWR _1244_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1326_ _1788_/CLK _1326_/D VGND VPWR _1327_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_56_305 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1257_ _1302_/CLK _1257_/D VGND VPWR _1258_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0208_ _0316_/CLK _0208_/D VGND VPWR _0210_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1188_ _1816_/CLK _1188_/D VGND VPWR _1189_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_224 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0139_ _1162_/CLK _0139_/D VGND VPWR _0140_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_208 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_187 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0490_ _0998_/CLK _0490_/D VGND VPWR _0491_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_65_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1111_ _1841_/CLK _1111_/D VGND VPWR _1122_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1042_ _1046_/CLK _1042_/D VGND VPWR _1043_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_308 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_330 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1944_ _1975_/CLK _1944_/D VGND VPWR _1945_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1875_ _1995_/CLK _1875_/D VGND VPWR _1876_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0826_ _0845_/CLK _0826_/D VGND VPWR _0827_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0757_ _0761_/CLK _0757_/D VGND VPWR _0758_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0688_ _0906_/CLK _0688_/D VGND VPWR _0689_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_15_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_15_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_57_603 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1309_ _1320_/CLK _1309_/D VGND VPWR _1310_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_249 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_330 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1660_ _1665_/CLK _1660_/D VGND VPWR _1661_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_7_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1591_ _1600_/CLK _1591_/D VGND VPWR _1592_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0611_ _0632_/CLK _0611_/D VGND VPWR _0612_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_50_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0542_ _0573_/CLK _0542_/D VGND VPWR _0543_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0473_ _0539_/CLK _0473_/D VGND VPWR _0484_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1025_ _1033_/CLK _1025_/D VGND VPWR _1026_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_330 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_580 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1927_ _1936_/CLK _1927_/D VGND VPWR _1928_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1858_ _1858_/CLK _1858_/D VGND VPWR _1859_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0809_ _0813_/CLK _0809_/D VGND VPWR _0810_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1789_ _1833_/CLK _1789_/D VGND VPWR _1800_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_429 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_293 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_536 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_208 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_274 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_580 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1712_ _1726_/CLK _1712_/D VGND VPWR _1713_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1643_ _1649_/CLK _1643_/D VGND VPWR _1644_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XANTENNA_1 _1182_/D VGND VPWR VPWR VGND sky130_fd_sc_hd__diode_2
X_1574_ _1592_/CLK _1574_/D VGND VPWR _1575_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_333 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0525_ _1182_/CLK _0525_/D VGND VPWR _0526_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0456_ _0585_/CLK _0456_/D VGND VPWR _0457_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0387_ _0908_/CLK _0387_/D VGND VPWR _0388_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_17 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1008_ _1017_/CLK _1008_/D VGND VPWR _1009_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_248 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_606 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_609 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_160 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput3 _1182_/D VGND VPWR out_window[1] VGND VPWR sky130_fd_sc_hd__clkbuf_2
X_0310_ _1046_/CLK _0310_/D VGND VPWR _0311_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1290_ _1336_/CLK _1290_/D VGND VPWR _1291_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0241_ _1980_/CLK _0241_/D VGND VPWR _0243_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0172_ _1178_/CLK _0172_/D VGND VPWR _0173_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_23_108 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1626_ _1673_/CLK _1626_/D VGND VPWR _1627_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1557_ _1907_/CLK _1557_/D VGND VPWR _1558_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0508_ _0508_/CLK _0508_/D VGND VPWR _0509_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_163 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1488_ _1965_/CLK _1488_/D VGND VPWR _1489_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0439_ _0973_/CLK _0439_/D VGND VPWR _0441_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_575 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_244 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0790_ _0793_/CLK _0790_/D VGND VPWR _0791_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_42_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1411_ _1710_/CLK _1411_/D VGND VPWR _1412_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1342_ _1772_/CLK _1342_/D VGND VPWR _1343_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1273_ _1348_/CLK _1273_/D VGND VPWR _1274_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0224_ _1996_/CLK _0224_/D VGND VPWR _0225_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_564 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0155_ _1170_/CLK _0155_/D VGND VPWR _0156_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_51_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0086_ _1229_/CLK _0086_/D VGND VPWR _0087_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0988_ _1017_/CLK _0988_/D VGND VPWR _0989_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1609_ _1965_/CLK _1609_/D VGND VPWR _1610_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_339 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_103 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_188 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_472 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1960_ _1973_/CLK _1960_/D VGND VPWR _1961_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0911_ _0919_/CLK _0911_/D VGND VPWR _0912_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1891_ _1991_/CLK _1891_/D VGND VPWR _1892_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0842_ _0864_/CLK _0842_/D VGND VPWR _0843_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0773_ _0845_/CLK _0773_/D VGND VPWR _0774_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1325_ _1336_/CLK _1325_/D VGND VPWR _1326_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_166 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1256_ _1302_/CLK _1256_/D VGND VPWR _1257_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0207_ _0214_/CLK _0207_/D VGND VPWR _0208_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1187_ _1841_/CLK _1187_/D VGND VPWR _1188_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0138_ _1162_/CLK _0138_/D VGND VPWR _0139_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_24_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_209 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0069_ _1816_/CLK _0069_/D VGND VPWR _0070_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_361 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_497 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1110_ _1163_/CLK _1110_/D VGND VPWR _1112_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_553 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1041_ _1055_/CLK _1041_/D VGND VPWR _1042_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1943_ _1987_/CLK _1943_/D VGND VPWR _1954_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1874_ _1995_/CLK _1874_/D VGND VPWR _1875_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0825_ _1827_/CLK _0825_/D VGND VPWR _0836_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0756_ _0761_/CLK _0756_/D VGND VPWR _0757_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0687_ _0898_/CLK _0687_/D VGND VPWR _0688_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_328 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1308_ _1320_/CLK _1308_/D VGND VPWR _1309_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_25_501 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1239_ _1244_/CLK _1239_/D VGND VPWR _1240_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_342 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_388 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_434 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_545 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_589 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_386 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1590_ _1600_/CLK _1590_/D VGND VPWR _1591_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0610_ _0610_/CLK _0610_/D VGND VPWR _0611_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0541_ _0573_/CLK _0541_/D VGND VPWR _0542_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_526 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_482 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0472_ _0998_/CLK _0472_/D VGND VPWR _0474_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_66_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_445 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_136 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_309 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_618 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1024_ _1039_/CLK _1024_/D VGND VPWR _1025_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_61_161 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_397 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1926_ _1956_/CLK _1926_/D VGND VPWR _1927_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_30_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1857_ _1997_/CLK _1857_/D VGND VPWR _1858_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0808_ _0906_/CLK _0808_/D VGND VPWR _0809_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1788_ _1788_/CLK _1788_/D VGND VPWR _1790_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0739_ _0761_/CLK _0739_/D VGND VPWR _0740_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_57_401 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_415 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_353 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_345 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_618 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_14_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_14_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
X_1711_ _1726_/CLK _1711_/D VGND VPWR _1712_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1642_ _1649_/CLK _1642_/D VGND VPWR _1643_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1573_ _1592_/CLK _1573_/D VGND VPWR _1574_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0524_ _0529_/CLK _0524_/D VGND VPWR _0525_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0455_ _0585_/CLK _0455_/D VGND VPWR _0456_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_39_423 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0386_ _1103_/CLK _0386_/D VGND VPWR _0387_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XPHY_18 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1007_ _1010_/CLK _1007_/D VGND VPWR _1008_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1909_ _1918_/CLK _1909_/D VGND VPWR _1911_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_205 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_58 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_106 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_223 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput4 _1183_/D VGND VPWR out_window[2] VGND VPWR sky130_fd_sc_hd__clkbuf_2
X_0240_ _0295_/CLK _0240_/D VGND VPWR _0241_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_253 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0171_ _1180_/CLK _0171_/D VGND VPWR _0172_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_48_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_120_clk clkbuf_4_0_0_clk/X VGND VPWR _1373_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1625_ _1673_/CLK _1625_/D VGND VPWR _1626_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1556_ _1592_/CLK _1556_/D VGND VPWR _1557_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0507_ _0508_/CLK _0507_/D VGND VPWR _0508_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1487_ _1965_/CLK _1487_/D VGND VPWR _1488_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0438_ _0973_/CLK _0438_/D VGND VPWR _0439_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0369_ _1088_/CLK _0369_/D VGND VPWR _0370_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_554 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_297 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_111_clk clkbuf_4_1_0_clk/X VGND VPWR _1695_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_89_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_102_clk clkbuf_4_6_0_clk/X VGND VPWR _1659_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1410_ _1710_/CLK _1410_/D VGND VPWR _1411_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_68_304 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1341_ _1373_/CLK _1341_/D VGND VPWR _1342_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_624 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1272_ _1272_/CLK _1272_/D VGND VPWR _1273_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0223_ _1996_/CLK _0223_/D VGND VPWR _0224_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0154_ _1600_/CLK _0154_/D VGND VPWR _0165_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_245 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_237 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0085_ _1229_/CLK _0085_/D VGND VPWR _0086_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_624 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_495 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0987_ _1017_/CLK _0987_/D VGND VPWR _0988_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1608_ _1611_/CLK _1608_/D VGND VPWR _1609_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_87_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1539_ _1578_/CLK _1539_/D VGND VPWR _1540_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_473 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0910_ _0916_/CLK _0910_/D VGND VPWR _0911_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_53_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1890_ _1991_/CLK _1890_/D VGND VPWR _1891_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0841_ _0864_/CLK _0841_/D VGND VPWR _0842_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0772_ _0791_/CLK _0772_/D VGND VPWR _0773_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_5_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1324_ _1788_/CLK _1324_/D VGND VPWR _1325_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_84_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1255_ _1272_/CLK _1255_/D VGND VPWR _1256_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_83_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_381 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0206_ _1178_/CLK _0206_/D VGND VPWR _0207_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1186_ _1816_/CLK _1186_/D VGND VPWR _1187_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0137_ _1185_/CLK _0137_/D VGND VPWR _0138_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0068_ _1816_/CLK _0068_/D VGND VPWR _0069_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_454 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_281 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_220 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_329 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_229 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_11 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_424 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_457 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_608 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1040_ _1046_/CLK _1040_/D VGND VPWR _1041_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1942_ _1975_/CLK _1942_/D VGND VPWR _1944_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_9_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1873_ _1995_/CLK _1873_/D VGND VPWR _1874_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0824_ _0845_/CLK _0824_/D VGND VPWR _0826_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0755_ _0761_/CLK _0755_/D VGND VPWR _0756_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0686_ _0898_/CLK _0686_/D VGND VPWR _0687_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_529 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_432 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_240 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_465 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1307_ _1320_/CLK _1307_/D VGND VPWR _1308_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1238_ _1272_/CLK _1238_/D VGND VPWR _1239_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_91_clk clkbuf_4_5_0_clk/X VGND VPWR _1587_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1169_ _1180_/CLK _1169_/D VGND VPWR _1170_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_52_321 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_354 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_301 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_601 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_584 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_340 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_82_clk clkbuf_4_7_0_clk/X VGND VPWR _1991_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_7_244 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0540_ _1182_/CLK _0540_/D VGND VPWR _0541_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_461 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_494 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0471_ _0998_/CLK _0471_/D VGND VPWR _0472_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_98_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_413 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_129 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1023_ _1686_/CLK _1023_/D VGND VPWR _1034_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_73_clk clkbuf_4_12_0_clk/X VGND VPWR _0316_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_34_365 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_354 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1925_ _1936_/CLK _1925_/D VGND VPWR _1926_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1856_ _1862_/CLK _1856_/D VGND VPWR _1857_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1787_ _1794_/CLK _1787_/D VGND VPWR _1788_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0807_ _0906_/CLK _0807_/D VGND VPWR _0808_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0738_ _1138_/CLK _0738_/D VGND VPWR _0739_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_409 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0669_ _0874_/CLK _0669_/D VGND VPWR _0670_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_337 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_273 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_287 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_332 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_64_clk clkbuf_4_13_0_clk/X VGND VPWR _1039_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_37_181 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_505 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_357 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_593 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_131 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_153 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_197 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_55_clk clkbuf_4_14_0_clk/X VGND VPWR _0595_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_63_449 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_560 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1710_ _1710_/CLK _1710_/D VGND VPWR _1711_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1641_ _1659_/CLK _1641_/D VGND VPWR _1642_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1572_ _1592_/CLK _1572_/D VGND VPWR _1573_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0523_ _0529_/CLK _0523_/D VGND VPWR _0524_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0454_ _0585_/CLK _0454_/D VGND VPWR _0455_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0385_ _1918_/CLK _0385_/D VGND VPWR _0396_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_54_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_46_clk clkbuf_4_12_0_clk/X VGND VPWR _1070_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1006_ _1010_/CLK _1006_/D VGND VPWR _1007_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_22_302 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_335 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1908_ _1936_/CLK _1908_/D VGND VPWR _1909_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1839_ _1846_/CLK _1839_/D VGND VPWR _1840_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_1_217 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_37_clk clkbuf_4_11_0_clk/X VGND VPWR _0642_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_31_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_578 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput5 _1183_/Q VGND VPWR out_window[3] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_68_508 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_500 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0170_ _1180_/CLK _0170_/D VGND VPWR _0171_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_416 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_28_clk clkbuf_4_10_0_clk/X VGND VPWR _0845_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
XFILLER_44_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_1624_ _1673_/CLK _1624_/D VGND VPWR _1625_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1555_ _1918_/CLK _1555_/D VGND VPWR _1556_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_605 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0506_ _0539_/CLK _0506_/D VGND VPWR _0517_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1486_ _1965_/CLK _1486_/D VGND VPWR _1487_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_100_137 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0437_ _0973_/CLK _0437_/D VGND VPWR _0438_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_221 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0368_ _1112_/CLK _0368_/D VGND VPWR _0369_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_67_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_19_clk clkbuf_4_8_0_clk/X VGND VPWR _1147_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_0299_ _0316_/CLK _0299_/D VGND VPWR _0300_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_35_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_452 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_13_0_clk clkbuf_0_clk/X VGND VPWR clkbuf_4_13_0_clk/X VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_14_622 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_588 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_493 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_441 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_169 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_386 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1340_ _1772_/CLK _1340_/D VGND VPWR _1341_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1271_ _1272_/CLK _1271_/D VGND VPWR _1272_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_541 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0222_ _1996_/CLK _0222_/D VGND VPWR _0223_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_585 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0153_ _1170_/CLK _0153_/D VGND VPWR _0155_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_36_213 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0084_ _1229_/CLK _0084_/D VGND VPWR _0085_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0986_ _1039_/CLK _0986_/D VGND VPWR _0987_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_8_clk clkbuf_4_2_0_clk/X VGND VPWR _1228_/CLK VGND VPWR sky130_fd_sc_hd__clkbuf_16
X_1607_ _1611_/CLK _1607_/D VGND VPWR _1608_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1538_ _1592_/CLK _1538_/D VGND VPWR _1539_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_99_485 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1469_ _1726_/CLK _1469_/D VGND VPWR _1470_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_86_157 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_607 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_625 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_284 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_216 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0840_ _0864_/CLK _0840_/D VGND VPWR _0841_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0771_ _0791_/CLK _0771_/D VGND VPWR _0772_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_38_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1323_ _1788_/CLK _1323_/D VGND VPWR _1324_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1254_ _1302_/CLK _1254_/D VGND VPWR _1255_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_96_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0205_ _1178_/CLK _0205_/D VGND VPWR _0206_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_49_393 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_1185_ _1185_/CLK _1185_/D VGND VPWR _1186_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0136_ _1147_/CLK _0136_/D VGND VPWR _0137_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_37_577 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0067_ _1185_/CLK _0067_/D VGND VPWR _0068_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_20_433 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_466 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_0969_ _0973_/CLK _0969_/D VGND VPWR _0970_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_3_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_549 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_522 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_276 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_437 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_96 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_533 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_190 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_569 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1941_ _1975_/CLK _1941_/D VGND VPWR _1942_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1872_ _1995_/CLK _1872_/D VGND VPWR _1873_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0823_ _0831_/CLK _0823_/D VGND VPWR _0824_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0754_ _0761_/CLK _0754_/D VGND VPWR _0755_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0685_ _0898_/CLK _0685_/D VGND VPWR _0686_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_444 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1306_ _1336_/CLK _1306_/D VGND VPWR _1307_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_69_477 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_296 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1237_ _1272_/CLK _1237_/D VGND VPWR _1238_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1168_ _1180_/CLK _1168_/D VGND VPWR _1169_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_64_193 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_0119_ _1138_/CLK _0119_/D VGND VPWR _0120_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_44_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_1099_ _1104_/CLK _1099_/D VGND VPWR _1101_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_40_528 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_613 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_47 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_396 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_366 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_263 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0470_ _0977_/CLK _0470_/D VGND VPWR _0471_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_78_241 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1022_ _1033_/CLK _1022_/D VGND VPWR _1024_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_377 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1924_ _1936_/CLK _1924_/D VGND VPWR _1925_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1855_ _1987_/CLK _1855_/D VGND VPWR _1866_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1786_ _1794_/CLK _1786_/D VGND VPWR _1787_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0806_ _0813_/CLK _0806_/D VGND VPWR _0807_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0737_ _1827_/CLK _0737_/D VGND VPWR _0748_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0668_ _0916_/CLK _0668_/D VGND VPWR _0669_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_103_349 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_0599_ _0632_/CLK _0599_/D VGND VPWR _0600_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_29_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_149 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_299 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_517 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_325 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_561 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_165 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_421 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_360 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_269 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_185 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_521 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1640_ _1649_/CLK _1640_/D VGND VPWR _1641_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1571_ _1592_/CLK _1571_/D VGND VPWR _1572_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0522_ _1182_/CLK _0522_/D VGND VPWR _0523_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0453_ _0585_/CLK _0453_/D VGND VPWR _0454_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_79_550 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_0384_ _0908_/CLK _0384_/D VGND VPWR _0386_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_94_520 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_233 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_225 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_480 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1005_ _1010_/CLK _1005_/D VGND VPWR _1006_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_34_141 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_1907_ _1907_/CLK _1907_/D VGND VPWR _1908_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1838_ _1846_/CLK _1838_/D VGND VPWR _1839_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1769_ _1788_/CLK _1769_/D VGND VPWR _1770_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_85_586 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_612 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_557 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_317 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_277 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_556 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_180 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_191 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_395 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_1623_ _1673_/CLK _1623_/D VGND VPWR _1624_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1554_ _1907_/CLK _1554_/D VGND VPWR _1555_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_1485_ _1965_/CLK _1485_/D VGND VPWR _1486_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
X_0505_ _0508_/CLK _0505_/D VGND VPWR _0507_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
XFILLER_101_617 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_0436_ _0966_/CLK _0436_/D VGND VPWR _0437_/D VGND VPWR sky130_fd_sc_hd__dfxtp_1
.ends

.subckt sky130_fd_sc_hd__inv_4 A VGND VPWR Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=5.4e+11p pd=5.08e+06u as=7.9e+11p ps=7.58e+06u w=1e+06u l=150000u
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=3.51e+11p pd=3.68e+06u as=5.135e+11p ps=5.48e+06u w=650000u l=150000u
X2 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X7 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt ring-osc-flat w_n269_31# gnd w_n336_309# q10 vdd1 w_n336_n534#
X0 q6 q5 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+12p ps=2.52e+07u w=1e+06u l=150000u
X1 gnd q17 q18 w_n269_31# sky130_fd_pr__nfet_01v8 ad=3.211e+12p pd=3.458e+07u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X2 q9 q8 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X3 q3 q2 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X4 q7 q6 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X5 a_n142_n449# q0 a_n224_n449# w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X6 q9 q8 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X7 vdd q15 q16 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=2.34e+12p pd=2.268e+07u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X8 vdd q11 q12 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X9 gnd q10 q11 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X10 gnd q13 q14 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X11 vdd q14 q15 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X12 q7 q6 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X13 q10 q9 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X14 vdd q17 q18 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X15 q5 q4 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X16 gnd q18 q0 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X17 q2 q1 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X18 q4 q3 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X19 q1 q0 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X20 q3 q2 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X21 gnd q16 q17 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X22 vdd q10 q11 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X23 q10 q9 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X24 gnd q12 q13 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X25 vdd q13 q14 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X26 vdd q18 q0 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X27 q5 q4 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X28 q8 q7 vdd1 w_n336_309# sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X29 q6 q5 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X30 q1 q0 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X31 a_n142_n129# q0 a_n224_n129# w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X32 q8 q7 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X33 gnd q15 q16 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X34 gnd q11 q12 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X35 vdd q16 q17 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X36 vdd q12 q13 w_n336_n534# sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
X37 q2 q1 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X38 q4 q3 gnd w_n269_31# sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X39 gnd q14 q15 w_n269_31# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_16 A VGND VPWR Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.16e+12p pd=2.032e+07u as=2.41e+12p ps=2.282e+07u w=1e+06u l=150000u
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X2 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=1.5665e+12p pd=1.652e+07u as=1.404e+12p ps=1.472e+07u w=650000u l=150000u
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X6 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X9 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X10 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X11 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X12 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X14 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X15 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X16 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X17 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X18 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X20 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X21 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X22 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X23 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X24 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X25 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X26 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X27 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X28 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X29 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X30 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X31 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_1 A VGND VPWR Y VNB VPB
X0 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=1.69e+11p ps=1.82e+06u w=650000u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=2.6e+11p ps=2.52e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VPWR X VNB VPB
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.646e+11p pd=2.94e+06u as=8.895e+11p ps=6.3e+06u w=420000u l=150000u
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=1.596e+11p pd=1.6e+06u as=1.218e+11p ps=1.42e+06u w=420000u l=150000u
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.6e+11p pd=2.52e+06u as=0p ps=0u w=1e+06u l=150000u
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=1.386e+11p pd=1.5e+06u as=0p ps=0u w=420000u l=150000u
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=3.9255e+11p pd=2.66e+06u as=0p ps=0u w=420000u l=150000u
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.69e+11p pd=1.82e+06u as=0p ps=0u w=650000u l=150000u
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.092e+11p ps=1.36e+06u w=420000u l=150000u
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VPWR X VNB VPB
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=2.291e+11p pd=2.16e+06u as=2.054e+11p ps=2.1e+06u w=790000u l=150000u
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=1.352e+11p pd=1.56e+06u as=1.508e+11p ps=1.62e+06u w=520000u l=150000u
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.054e+11p pd=2.1e+06u as=0p ps=0u w=790000u l=150000u
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.352e+11p ps=1.56e+06u w=520000u l=150000u
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VPWR Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=2.7e+11p pd=2.54e+06u as=5.2e+11p ps=5.04e+06u w=1e+06u l=150000u
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=3.38e+11p pd=3.64e+06u as=1.755e+11p ps=1.84e+06u w=650000u l=150000u
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=650000u l=150000u
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt analog_switch_decoder addr[1] addr[2] addr[3] fet_on[0] fet_on[10] fet_on[11]
+ fet_on[12] fet_on[13] fet_on[14] fet_on[15] fet_on[1] fet_on[2] fet_on[3] fet_on[4]
+ fet_on[5] fet_on[6] fet_on[7] fet_on[8] fet_on[9] input1/A VPWR VGND
XFILLER_9_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_98 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_98 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput7 _35_/X VGND VPWR fet_on[11] VGND VPWR sky130_fd_sc_hd__clkbuf_2
Xoutput20 _33_/X VGND VPWR fet_on[9] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_3_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xoutput10 _38_/X VGND VPWR fet_on[14] VGND VPWR sky130_fd_sc_hd__clkbuf_2
Xoutput8 _36_/X VGND VPWR fet_on[12] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_16_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_124 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xoutput9 _37_/X VGND VPWR fet_on[13] VGND VPWR sky130_fd_sc_hd__clkbuf_2
Xoutput11 _39_/X VGND VPWR fet_on[15] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_16_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_103 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_29_ _38_/A _34_/B _30_/C _36_/D VGND VPWR _29_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_6_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput12 _21_/X VGND VPWR fet_on[1] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_15_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_28_ _39_/A VGND VPWR _38_/A VGND VPWR sky130_fd_sc_hd__buf_1
Xoutput13 _22_/X VGND VPWR fet_on[2] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_15_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_91 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_27_ _33_/A _37_/B _30_/C _36_/D VGND VPWR _27_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_20_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput14 _23_/X VGND VPWR fet_on[3] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XPHY_0 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_26_ _39_/B VGND VPWR _37_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_6_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput15 _25_/X VGND VPWR fet_on[4] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XPHY_1 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_25_ _33_/A _34_/B _25_/C _36_/D VGND VPWR _25_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_19_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_61 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput16 _27_/X VGND VPWR fet_on[5] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_15_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_2 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_72 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_24_ _39_/D VGND VPWR _36_/D VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_19_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xoutput17 _29_/X VGND VPWR fet_on[6] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XPHY_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_23_ _25_/C _32_/D _39_/A _39_/B VGND VPWR _23_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_10_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xoutput18 _30_/X VGND VPWR fet_on[7] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_21_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_4 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_64 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_110 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_22_ _25_/C _32_/D _39_/A _38_/B VGND VPWR _22_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_19_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
Xoutput19 _32_/X VGND VPWR fet_on[8] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XPHY_5 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_122 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_21_ _25_/C _32_/D _37_/A _39_/B VGND VPWR _21_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_16_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_6 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_20_ _33_/A _34_/B _25_/C _32_/D VGND VPWR _20_/X VGND VPWR sky130_fd_sc_hd__and4_1
Xinput1 input1/A VGND VPWR _39_/B VGND VPWR sky130_fd_sc_hd__clkbuf_2
XPHY_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_89 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xinput2 addr[1] VGND VPWR _39_/A VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_10_67 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_8 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xinput3 addr[2] VGND VPWR _39_/D VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_18_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_9 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_79 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
Xinput4 addr[3] VGND VPWR _39_/C VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_18_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_48 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_80 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_49 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_92 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_101 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_60 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_39_ _39_/A _39_/B _39_/C _39_/D VGND VPWR _39_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_7_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_72 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_73 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_38_ _38_/A _38_/B _39_/C _39_/D VGND VPWR _38_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_7_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_37_ _37_/A _37_/B _39_/C _39_/D VGND VPWR _37_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_22_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_40 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_36_ _37_/A _38_/B _36_/C _36_/D VGND VPWR _36_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_22_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_19_ _35_/D VGND VPWR _32_/D VGND VPWR sky130_fd_sc_hd__buf_1
XPHY_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_30 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_87 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_35_ _38_/A _37_/B _36_/C _35_/D VGND VPWR _35_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_11_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_18_ _39_/D VGND VPWR _35_/D VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_4_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_42 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_99 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_66 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_34_ _38_/A _34_/B _36_/C _35_/D VGND VPWR _34_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_11_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_17_ _30_/C VGND VPWR _25_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_33_ _33_/A _37_/B _36_/C _35_/D VGND VPWR _33_/X VGND VPWR sky130_fd_sc_hd__and4_1
X_16_ _39_/C VGND VPWR _30_/C VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_3_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_44 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
X_32_ _33_/A _34_/B _36_/C _32_/D VGND VPWR _32_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_7_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_15_ _38_/B VGND VPWR _34_/B VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_12 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
X_31_ _39_/C VGND VPWR _36_/C VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_81 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
X_14_ _39_/B VGND VPWR _38_/B VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_3_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_57 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_92 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_35 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_13 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_30_ _38_/A _37_/B _30_/C _36_/D VGND VPWR _30_/X VGND VPWR sky130_fd_sc_hd__and4_1
XFILLER_3_93 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_7 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
X_13_ _37_/A VGND VPWR _33_/A VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_3_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_69 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_117 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_92 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_36 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_49 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
X_12_ _39_/A VGND VPWR _37_/A VGND VPWR sky130_fd_sc_hd__inv_2
XFILLER_17_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_51 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_49 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_37 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_128 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_38 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_61 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_121 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_109 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_28 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_39 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_105 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_31 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_133 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_104 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_21 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_29 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_113 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_43 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_74 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_116 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_75 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_65 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_19 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_3
Xoutput5 _20_/X VGND VPWR fet_on[0] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_15_52 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_132 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_125 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_85 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_41 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_53 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_97 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_3 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_77 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_6
Xoutput6 _34_/X VGND VPWR fet_on[10] VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_15_86 VGND VPWR VGND VPWR sky130_fd_sc_hd__decap_12
.ends

.subckt top shift_reg_9/VPWR shift_reg_33/out_window[1] shift_reg_33/out_window[3]
+ analog_switch_decoder_0/addr[2] analog_switch_decoder_0/input1/A shift_reg_9/clk
+ shift_reg_33/out_window[0] a_119260_592880# shift_reg_33/out_window[2] a_124150_642340#
+ analog_switch_decoder_0/addr[3] shift_reg_4/din switch-small_7/VDD shift_reg_9/VGND
+ a_119620_592570# analog_switch_decoder_0/addr[1] a_124150_642240#
Xswitch-small_4 a_119620_592570# a_125270_604730# switch-small_4/SIgnal switch-small
Xshift_reg_8 shift_reg_9/clk shift_reg_8/din shift_reg_8/out_window[0] shift_reg_9/din
+ shift_reg_8/out_window[2] shift_reg_8/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xswitch-small_5 a_119620_592570# a_125070_598370# switch-small_5/SIgnal switch-small
Xshift_reg_9 shift_reg_9/clk shift_reg_9/din shift_reg_9/out_window[0] shift_reg_10/din
+ shift_reg_9/out_window[2] shift_reg_9/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xswitch-small_6 a_119620_592570# a_125140_610880# switch-small_6/SIgnal switch-small
Xswitch-small_7 a_119620_592570# a_125490_618480# switch-small_7/SIgnal switch-small
Xshift_reg_20 shift_reg_9/clk shift_reg_20/din shift_reg_20/out_window[0] shift_reg_24/din
+ shift_reg_20/out_window[2] shift_reg_20/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_31 shift_reg_9/clk shift_reg_31/din shift_reg_31/out_window[0] shift_reg_30/din
+ shift_reg_31/out_window[2] shift_reg_31/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_30 shift_reg_9/clk shift_reg_30/din shift_reg_30/out_window[0] shift_reg_35/din
+ shift_reg_30/out_window[2] shift_reg_30/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_21 shift_reg_9/clk shift_reg_21/din shift_reg_21/out_window[0] shift_reg_27/din
+ shift_reg_21/out_window[2] shift_reg_21/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_10 shift_reg_9/clk shift_reg_10/din shift_reg_10/out_window[0] shift_reg_11/din
+ shift_reg_10/out_window[2] shift_reg_10/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_32 shift_reg_9/clk shift_reg_32/din shift_reg_32/out_window[0] shift_reg_33/din
+ shift_reg_32/out_window[2] shift_reg_32/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_11 shift_reg_9/clk shift_reg_11/din shift_reg_11/out_window[0] shift_reg_21/din
+ shift_reg_21/din shift_reg_11/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND shift_reg
Xshift_reg_22 shift_reg_9/clk shift_reg_22/din shift_reg_22/out_window[0] shift_reg_29/din
+ shift_reg_22/out_window[2] shift_reg_22/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_33 shift_reg_9/clk shift_reg_33/din shift_reg_33/out_window[0] shift_reg_33/out_window[1]
+ shift_reg_33/out_window[2] shift_reg_33/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_23 shift_reg_9/clk shift_reg_23/din shift_reg_23/out_window[0] shift_reg_22/din
+ shift_reg_23/out_window[2] shift_reg_23/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_12 shift_reg_9/clk shift_reg_12/din shift_reg_12/din shift_reg_13/din shift_reg_12/out_window[2]
+ shift_reg_12/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND shift_reg
Xshift_reg_34 shift_reg_9/clk shift_reg_34/din shift_reg_34/out_window[0] shift_reg_12/din
+ shift_reg_34/out_window[2] shift_reg_34/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_24 shift_reg_9/clk shift_reg_24/din shift_reg_24/out_window[0] shift_reg_23/din
+ shift_reg_24/out_window[2] shift_reg_24/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_13 shift_reg_9/clk shift_reg_13/din shift_reg_13/out_window[0] shift_reg_14/din
+ shift_reg_13/out_window[2] shift_reg_13/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_35 shift_reg_9/clk shift_reg_35/din shift_reg_35/out_window[0] shift_reg_34/din
+ shift_reg_35/out_window[2] shift_reg_35/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xsky130_fd_sc_hd__inv_4_0 sky130_fd_sc_hd__inv_4_0/A ring-osc-flat_0/gnd ring-osc-flat_0/vdd1
+ sky130_fd_sc_hd__inv_4_0/Y shift_reg_9/VGND sky130_fd_sc_hd__inv_4_0/VPB sky130_fd_sc_hd__inv_4
Xshift_reg_25 shift_reg_9/clk shift_reg_25/din shift_reg_25/out_window[0] shift_reg_31/din
+ shift_reg_25/out_window[2] shift_reg_25/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_14 shift_reg_9/clk shift_reg_14/din shift_reg_14/out_window[0] shift_reg_15/din
+ shift_reg_14/out_window[2] shift_reg_14/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_26 shift_reg_9/clk shift_reg_26/din shift_reg_26/out_window[0] shift_reg_25/din
+ shift_reg_26/out_window[2] shift_reg_26/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_15 shift_reg_9/clk shift_reg_15/din shift_reg_15/out_window[0] shift_reg_16/din
+ shift_reg_15/out_window[2] shift_reg_15/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_27 shift_reg_9/clk shift_reg_27/din shift_reg_27/out_window[0] shift_reg_26/din
+ shift_reg_27/out_window[2] shift_reg_27/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_16 shift_reg_9/clk shift_reg_16/din shift_reg_16/out_window[0] shift_reg_17/din
+ shift_reg_16/out_window[2] shift_reg_16/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_18 shift_reg_9/clk shift_reg_18/din shift_reg_18/out_window[0] shift_reg_19/din
+ shift_reg_18/out_window[2] shift_reg_18/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_17 shift_reg_9/clk shift_reg_17/din shift_reg_17/out_window[0] shift_reg_18/din
+ shift_reg_17/out_window[2] shift_reg_17/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_29 shift_reg_9/clk shift_reg_29/din shift_reg_29/out_window[0] shift_reg_28/din
+ shift_reg_29/out_window[2] shift_reg_29/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_28 shift_reg_9/clk shift_reg_28/din shift_reg_28/out_window[0] shift_reg_32/din
+ shift_reg_28/out_window[2] shift_reg_28/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xshift_reg_19 shift_reg_9/clk shift_reg_19/din shift_reg_19/out_window[0] shift_reg_20/din
+ shift_reg_20/din shift_reg_19/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND shift_reg
Xring-osc-flat_0 shift_reg_9/VGND ring-osc-flat_0/gnd sky130_fd_sc_hd__inv_4_0/VPB
+ ring-osc-flat_0/q10 ring-osc-flat_0/vdd1 w_n336_n534# ring-osc-flat
Xswitch-small_0 a_119620_592570# a_124020_642690# switch-small_0/SIgnal switch-small
Xshift_reg_4 shift_reg_9/clk shift_reg_4/din shift_reg_4/out_window[0] shift_reg_5/din
+ shift_reg_4/out_window[2] shift_reg_4/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xsky130_fd_sc_hd__inv_16_0 sky130_fd_sc_hd__inv_4_0/Y ring-osc-flat_0/gnd ring-osc-flat_0/vdd1
+ sky130_fd_sc_hd__inv_16_0/Y shift_reg_9/VGND sky130_fd_sc_hd__inv_4_0/VPB sky130_fd_sc_hd__inv_16
Xsky130_fd_sc_hd__inv_1_0 ring-osc-flat_0/q10 ring-osc-flat_0/gnd ring-osc-flat_0/vdd1
+ sky130_fd_sc_hd__inv_4_0/A shift_reg_9/VGND sky130_fd_sc_hd__inv_4_0/VPB sky130_fd_sc_hd__inv_1
Xswitch-small_1 a_119620_592570# a_124050_636110# SIgnal switch-small
Xshift_reg_5 shift_reg_9/clk shift_reg_5/din shift_reg_5/out_window[0] shift_reg_6/din
+ shift_reg_5/out_window[2] shift_reg_5/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xswitch-small_2 a_119620_592570# a_124330_630080# switch-small_2/SIgnal switch-small
Xshift_reg_6 shift_reg_9/clk shift_reg_6/din shift_reg_6/out_window[0] shift_reg_7/din
+ shift_reg_6/out_window[2] shift_reg_6/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
Xanalog_switch_decoder_0 analog_switch_decoder_0/addr[1] analog_switch_decoder_0/addr[2]
+ analog_switch_decoder_0/addr[3] switch-small_7/SIgnal switch-small_5/SIgnal analog_switch_decoder_0/fet_on[11]
+ switch-small_2/SIgnal analog_switch_decoder_0/fet_on[13] SIgnal analog_switch_decoder_0/fet_on[15]
+ analog_switch_decoder_0/fet_on[1] analog_switch_decoder_0/fet_on[2] switch-small_6/SIgnal
+ analog_switch_decoder_0/fet_on[4] switch-small_3/SIgnal analog_switch_decoder_0/fet_on[6]
+ analog_switch_decoder_0/fet_on[7] switch-small_0/SIgnal switch-small_4/SIgnal analog_switch_decoder_0/input1/A
+ switch-small_7/VDD shift_reg_9/VGND analog_switch_decoder
Xswitch-small_3 a_119620_592570# a_124580_623950# switch-small_3/SIgnal switch-small
Xshift_reg_7 shift_reg_9/clk shift_reg_7/din shift_reg_7/out_window[0] shift_reg_8/din
+ shift_reg_7/out_window[2] shift_reg_7/out_window[3] shift_reg_9/VPWR shift_reg_9/VGND
+ shift_reg
X0 shift_reg_9/VGND a_119360_592880# a_119720_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-1.4711e+16p pd=1.02883e+12u as=7e+11p ps=5.4e+06u w=1e+06u l=150000u
X1 a_119800_574010# analog_switch_decoder_0/fet_on[1] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=7e+11p pd=5.4e+06u as=5.6e+12p ps=4.32e+07u w=1e+06u l=150000u
X2 a_124150_642340# a_124580_623950# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=2.1533e+14p pd=1.117e+09u as=4.7202e+14p ps=3.1728e+09u w=3e+06u l=150000u
X3 shift_reg_9/VGND analog_switch_decoder_0/fet_on[15] a_119720_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=4.31947e+15p pd=5.61542e+10u as=7e+11p ps=5.4e+06u w=1e+06u l=150000u
X4 a_125490_573980# a_125460_573950# a_125390_573900# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X5 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X6 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X7 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X8 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X9 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X10 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X11 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X12 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X13 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X14 shift_reg_9/VGND a_119460_553280# a_119820_552970# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=7e+11p ps=5.4e+06u w=1e+06u l=150000u
X15 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X16 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X17 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X18 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X19 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X20 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X21 shift_reg_9/VGND analog_switch_decoder_0/fet_on[6] a_119760_583030# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=7e+11p ps=5.4e+06u w=1e+06u l=150000u
X22 shift_reg_9/VGND analog_switch_decoder_0/fet_on[4] a_119820_552970# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=7e+11p ps=5.4e+06u w=1e+06u l=150000u
X23 a_124150_642340# a_124580_623950# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=150000u
X24 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X25 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X26 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X27 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X28 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X29 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X30 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X31 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X32 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X33 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X34 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X35 shift_reg_9/VGND analog_switch_decoder_0/fet_on[1] a_119800_574010# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=7e+11p ps=5.4e+06u w=1e+06u l=150000u
X36 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X37 shift_reg_9/VGND a_119400_583340# a_119760_583030# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=7e+11p ps=5.4e+06u w=1e+06u l=150000u
X38 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X39 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X40 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X41 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X42 shift_reg_9/VGND a_119440_574320# a_119800_574010# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X43 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X44 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X45 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X46 a_124990_591980# a_124960_591950# a_124890_591900# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X47 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X48 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X49 a_125090_553910# a_125060_553880# a_124990_553830# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X50 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X51 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X52 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X53 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X54 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X55 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X56 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X57 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X58 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X59 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X60 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X61 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X62 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X63 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X64 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X65 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X66 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X67 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X68 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X69 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X70 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X71 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X72 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X73 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X74 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X75 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X76 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X77 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X78 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X79 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X80 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X81 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X82 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X83 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X84 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X85 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X86 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X87 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X88 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X89 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X90 a_119360_592880# analog_switch_decoder_0/fet_on[15] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X91 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X92 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X93 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X94 a_119820_545400# a_119460_545710# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=7e+11p pd=5.4e+06u as=5.6e+12p ps=4.32e+07u w=1e+06u l=150000u
X95 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X96 a_125100_611840# a_125070_611810# a_125000_611760# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X97 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X98 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X99 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X100 a_119750_559800# a_119390_560110# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=7e+11p pd=5.4e+06u as=0p ps=0u w=1e+06u l=150000u
X101 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X102 a_119430_537650# analog_switch_decoder_0/fet_on[11] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=1.83014e+14p ps=1.7724e+09u w=450000u l=150000u
X103 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X104 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X105 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X106 a_119750_566340# a_119390_566650# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=7e+11p pd=5.4e+06u as=0p ps=0u w=1e+06u l=150000u
X107 a_119820_545400# analog_switch_decoder_0/fet_on[7] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=7e+11p pd=5.4e+06u as=0p ps=0u w=1e+06u l=150000u
X108 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X109 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X110 a_124240_632580# a_124180_632550# a_124240_632480# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=7e+11p pd=4.7e+06u as=7e+11p ps=4.7e+06u w=2e+06u l=150000u
X111 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X112 a_125230_605790# a_125200_605760# a_125130_605710# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X113 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X114 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X115 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X116 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X117 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X118 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X119 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X120 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X121 a_119390_566650# analog_switch_decoder_0/fet_on[13] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=0p ps=0u w=450000u l=150000u
X122 a_119460_553280# analog_switch_decoder_0/fet_on[4] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X123 a_119750_566340# analog_switch_decoder_0/fet_on[13] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=7e+11p pd=5.4e+06u as=0p ps=0u w=1e+06u l=150000u
X124 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X125 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X126 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X127 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X128 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X129 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X130 a_124150_642340# a_124580_623950# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=150000u
X131 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X132 a_119440_574320# analog_switch_decoder_0/fet_on[1] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X133 a_119790_537340# a_119430_537650# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=7e+11p pd=5.4e+06u as=0p ps=0u w=1e+06u l=150000u
X134 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X135 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X136 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X137 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X138 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X139 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X140 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X141 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X142 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X143 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X144 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X145 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X146 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X147 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X148 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X149 shift_reg_9/VGND analog_switch_decoder_0/fet_on[7] a_119820_545400# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X150 a_124150_642340# a_124580_623950# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=150000u
X151 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X152 shift_reg_9/VGND analog_switch_decoder_0/fet_on[2] a_119750_559800# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X153 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X154 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X155 a_124220_624910# a_124160_624880# a_124220_624810# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.05e+12p pd=6.7e+06u as=1.05e+12p ps=6.7e+06u w=3e+06u l=150000u
X156 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X157 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X158 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X159 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X160 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X161 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X162 a_125440_566310# a_125410_566280# a_125340_566230# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X163 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X164 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X165 a_119790_537340# analog_switch_decoder_0/fet_on[11] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=7e+11p pd=5.4e+06u as=0p ps=0u w=1e+06u l=150000u
X166 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X167 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X168 shift_reg_9/VGND analog_switch_decoder_0/fet_on[13] a_119750_566340# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X169 shift_reg_9/VGND a_119460_545710# a_119820_545400# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X170 a_119460_545710# analog_switch_decoder_0/fet_on[7] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=0p ps=0u w=450000u l=150000u
X171 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X172 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X173 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X174 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X175 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X176 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X177 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X178 a_119400_583340# analog_switch_decoder_0/fet_on[6] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X179 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X180 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X181 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X182 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X183 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X184 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X185 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X186 shift_reg_9/VGND a_119390_566650# a_119750_566340# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X187 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X188 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X189 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X190 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X191 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X192 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X193 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X194 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X195 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X196 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X197 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X198 shift_reg_9/VGND analog_switch_decoder_0/fet_on[11] a_119790_537340# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X199 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X200 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X201 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X202 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X203 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X204 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X205 a_125090_546340# a_125060_546310# a_124990_546260# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X206 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X207 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X208 shift_reg_9/VGND a_119430_537650# a_119790_537340# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X209 a_125030_599530# a_125000_599500# a_124930_599450# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X210 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X211 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X212 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X213 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X214 a_119390_560110# analog_switch_decoder_0/fet_on[2] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=0p ps=0u w=450000u l=150000u
X215 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X216 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X217 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X218 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X219 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X220 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X221 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X222 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X223 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X224 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X225 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X226 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X227 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X228 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X229 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X230 a_124150_642340# a_124580_623950# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=150000u
X231 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X232 a_125060_538280# a_125030_538250# a_124960_538200# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X233 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X234 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X235 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X236 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X237 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X238 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X239 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X240 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X241 a_124150_642340# a_124580_623950# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3e+06u l=150000u
X242 a_125450_619290# a_125420_619260# a_125350_619210# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X243 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X244 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X245 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X246 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X247 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X248 a_119460_545710# analog_switch_decoder_0/fet_on[7] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X249 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X250 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X251 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X252 a_124150_642340# a_125270_604730# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X253 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X254 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X255 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X256 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X257 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X258 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X259 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X260 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X261 a_119750_559800# analog_switch_decoder_0/fet_on[2] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=7e+11p pd=5.4e+06u as=0p ps=0u w=1e+06u l=150000u
X262 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X263 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X264 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X265 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X266 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X267 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X268 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X269 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X270 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X271 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X272 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X273 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X274 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X275 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X276 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X277 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X278 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X279 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X280 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X281 a_119430_537650# analog_switch_decoder_0/fet_on[11] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X282 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X283 a_119360_592880# analog_switch_decoder_0/fet_on[15] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=0p ps=0u w=450000u l=150000u
X284 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X285 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X286 a_125440_559770# a_125410_559740# a_125340_559690# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X287 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X288 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X289 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X290 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X291 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X292 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X293 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X294 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X295 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X296 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X297 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X298 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X299 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X300 a_119390_560110# analog_switch_decoder_0/fet_on[2] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X301 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X302 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X303 a_119460_553280# analog_switch_decoder_0/fet_on[4] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=0p ps=0u w=450000u l=150000u
X304 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X305 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X306 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X307 a_124150_642340# a_119800_574010# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X308 a_119390_566650# analog_switch_decoder_0/fet_on[13] shift_reg_9/VGND shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.575e+11p pd=1.6e+06u as=-0p ps=0u w=450000u l=150000u
X309 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X310 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X311 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X312 a_124150_642340# a_119820_545400# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.125e+06u l=150000u
X313 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X314 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X315 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X316 a_119440_574320# analog_switch_decoder_0/fet_on[1] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=0p ps=0u w=450000u l=150000u
X317 shift_reg_9/VGND a_119390_560110# a_119750_559800# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=-0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X318 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X319 a_119720_592570# a_119360_592880# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X320 a_119720_592570# analog_switch_decoder_0/fet_on[15] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X321 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X322 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X323 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X324 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X325 a_124150_642340# a_125490_618480# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.125e+06u l=150000u
X326 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X327 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X328 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X329 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X330 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X331 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X332 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X333 a_124150_642340# a_119760_583030# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2.625e+06u l=150000u
X334 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X335 a_119820_552970# analog_switch_decoder_0/fet_on[4] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X336 a_124150_642340# a_119750_559800# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X337 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X338 a_119760_583030# a_119400_583340# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X339 a_119820_552970# a_119460_553280# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X340 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X341 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X342 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X343 a_124150_642340# a_119790_537340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=7.125e+06u l=150000u
X344 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X345 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X346 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X347 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X348 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X349 a_119400_583340# analog_switch_decoder_0/fet_on[6] switch-small_7/VDD switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=1.575e+11p pd=1.6e+06u as=0p ps=0u w=450000u l=150000u
X350 a_124150_642340# a_124050_636110# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=900000u l=150000u
X351 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X352 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X353 a_119800_574010# a_119440_574320# a_119620_592570# switch-small_7/VDD sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X354 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X355 a_124150_642340# a_119750_566340# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=4.625e+06u l=150000u
X356 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X357 a_124150_642340# a_125070_598370# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5.625e+06u l=150000u
X358 a_119760_583030# analog_switch_decoder_0/fet_on[6] a_119620_592570# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X359 a_125450_583000# a_125420_582970# a_125350_582920# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=1.6e+11p pd=1.6e+06u as=1.1525e+12p ps=8.2e+06u w=2.125e+06u l=150000u
X360 a_124150_642340# a_119820_552970# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.125e+06u l=150000u
X361 a_124150_642340# a_124330_630080# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X362 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
X363 a_124150_642340# a_124020_642690# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=450000u l=150000u
X364 a_124150_642340# a_125140_610880# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=3.625e+06u l=150000u
X365 a_124150_642340# a_119720_592570# a_124150_642240# shift_reg_9/VGND sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=6.625e+06u l=150000u
.ends

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[7] io_analog[8] io_analog[9]
+ io_analog[5] io_analog[6] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
Xtop_0 vccd1 io_out[1] io_out[4] io_in[17] io_in[15] io_in[13] io_out[3] vssa2 io_out[2]
+ io_analog[5] io_in[14] io_in[0] vccd2 vssa1 io_analog[6] io_in[16] io_analog[3]
+ top
.ends
